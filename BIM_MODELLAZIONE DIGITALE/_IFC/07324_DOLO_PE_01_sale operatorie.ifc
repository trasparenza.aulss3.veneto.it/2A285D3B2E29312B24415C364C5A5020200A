Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 8cc6c797-344e-47c1-b22d-4125323d93be, NumberOfSaves: 92], CoordinateReference [CoordinateBase: Coordinate condivise, ProjectSite: Interno]
File name: 07324
Time: 2025-02-28T15:46:00+01:00
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.11.26 (ITA) - IFC 24.1.11.26

# IfcProject: Ospedale di Dolo (VE), 07324
Description: PROGETTAZIONE ESECUTIVA DI N° 6 SALE OPERATORIE AL 3° PIANO BLOCCO EST OD 03D OSPEDALE DI DOLO (VE) - MODELLO ELETTRICO; LongName: 07324_DOLO_PE_01_sale operatorie; Phase: ESECUTIVO

# IfcSite: Ospedale di Dolo (VE)
Description: Via Louis Pasteur, 11, 30031 Dolo VE; LongName: Piano terzo pronto soccorso ospedale di Dolo; RefLatitude: 45, 25, 19, 889831; RefLongitude: 12, 4, 4, 325637; RefElevation: 0 mm

# IfcBuildingStorey: Livello:Livello 1 (2)
Name | LongName | Elevation (mm)
Livello 1 | Livello 1 | 0
A-03- sale operatorie | A-03- sale operatorie | 11910

# IfcBuildingElementProxy: Modelli generici : Allineatore_angolo_135 : Allineatore angolo 135° (92)
In: A-03- sale operatorie
Type - Material: Acciaio, Galvanizzato
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Allineatore_angolo_90 : Allineatore angolo 90° (18)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Allineatore_lineare : Allineatore std (428)
In: A-03- sale operatorie
Type - Material: Acciaio, Galvanizzato
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.04
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Anima_angolo_135 : Anima_EU (46)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Anima_angolo_90 : Anima_EU (9)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Binario : Binario_EU (183)
In: A-03- sale operatorie
Type - Material: Acciaio, Galvanizzato
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Binario_armadio : Predisposizione armadio (18)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Binario_armadio : Predisposizione passbox (6)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Carter_porta_scorrevole : Carter_porta_scorrevole (7)
In: A-03- sale operatorie
Type - Material: Alluminio anodizzato
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.2; DescrizioneElementoTecnico: Infissi interni verticali
Pset Descrizione Entità - Descrizione_Entità: Carter Porta Scorrevole
Pset RIF_Crono - RIF_CRONO: M10S36G10
Pset RIF_EPU - RIF_EPU: CIV.SO.26
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Cassaporta_abbracciante_Ditec : Cassaporta abbracciante (7)
In: A-03- sale operatorie
Type - Material: Alluminio anodizzato
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.2; DescrizioneElementoTecnico: Infissi interni verticali
Pset Descrizione Entità - Descrizione_Entità: Cassaporta
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.25
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Cremagliera_monitor_dx : Cremagliera corian DX (12)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.18
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Cremagliera_monitor_sx : Cremagliera corian DX (12)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.18
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Giunzione_angolo_90 : Giunzione angolo 90° (9)
In: A-03- sale operatorie
Type - Material: Acciaio, Galvanizzato
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Giunzione_lineare : Giunzione lineare std (46)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Montante : Montante_EU (101)
In: A-03- sale operatorie
Type - Material: Acciaio
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Panello_Armadio_sopraluce : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (31)
In: A-03- sale operatorie
Type - Material: Acciaio Sanisteel SANA 54 PMA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello Armadio sopraluce
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Panello_Armadio_sottoluce : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (6)
In: A-03- sale operatorie
Type - Material: Acciaio Sanisteel SANA 54 PMA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello Armadio sottoluce
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Panello_Gas_Centrale : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (13)
In: A-03- sale operatorie
Type - Material: Acciaio colaminato con PVC, Blue B1SA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Pannello gas centrale
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.17
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Panello_Gas_Sopraluce : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (13)
In: A-03- sale operatorie
Type - Material: Acciaio colaminato con PVC, Blue B1SA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Pannello gas sopraluce
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Panello_Gas_Sottoluce : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (13)
In: A-03- sale operatorie
Type - Material: Acciaio colaminato con PVC, Blue B1SA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello gas sottoluce
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Panello_TrueSpace_Base : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (154)
In: A-03- sale operatorie
Type - Material: Acciaio Sanisteel SANA 54 PMA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Panello_TrueSpace_Base : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (16)
In: A-03- sale operatorie
Type - Material: Acciaio colaminato con PVC, Blue B1SA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Pannello_TrueSpace_Sottoluce : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (6)
In: A-03- sale operatorie
Type - Material: Acciaio Sanisteel SANA 54 PMA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Pannello_angolo_esterno_90 : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (4)
In: A-03- sale operatorie
Type - Material: Acciaio Sanisteel SANA 54 PMA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Pannello_angolo_interno_135 : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (46)
In: A-03- sale operatorie
Type - Material: Acciaio Sanisteel SANA 54 PMA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Pannello_angolo_interno_90 : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (5)
In: A-03- sale operatorie
Type - Material: Acciaio Sanisteel SANA 54 PMA
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.10
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Pannello_vetro_monitor : Pannello_vetro_monitor (6)
In: A-03- sale operatorie
Type - Material: Pellicola nera Simil RAL 9005
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello vetrato per monitor
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.11
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Pannello_vetro_monitor : Pannello_vetro_monitor (6)
In: A-03- sale operatorie
Type - Material: Vetro Black Similar to RAL 9005
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Panello vetrato per monitor
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.11
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Piastra_supporto_monitor : Piastra supporto monitor (12)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Piastra supporto monitor
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.15
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Pressopiegato_superiore : Pressopiegato_EU (191)
In: A-03- sale operatorie
Type - Material: Acciaio, Galvanizzato
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.07
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Pressopiegato_superiore_angolo_135 : Pressopiegato superiore 135° (23)
In: A-03- sale operatorie
Type - Material: Default
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Profilo_controsoffitto : Profilo controsoffitto (214)
In: A-03- sale operatorie
Type - Material: Profilo soffitto Bianco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 2.2.2; DescrizioneElementoTecnico: Infissi orizzontali
Pset Descrizione Entità - Descrizione_Entità: Struttura controsoffitto
Pset RIF_Crono - RIF_CRONO: M07S24G50
Pset RIF_EPU - RIF_EPU: CIV.SO.43
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Profilo_controsoffitto_angolo_135 : Profilo controsoffitto (46)
In: A-03- sale operatorie
Type - Material: Profilo soffitto Bianco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 2.2.2; DescrizioneElementoTecnico: Infissi orizzontali
Pset Descrizione Entità - Descrizione_Entità: Struttura controsoffitto
Pset RIF_Crono - RIF_CRONO: M07S24G50
Pset RIF_EPU - RIF_EPU: CIV.SO.43
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Profilo_controsoffitto_angolo_esterno_90 : Profilo controsoffitto (4)
In: A-03- sale operatorie
Type - Material: Profilo soffitto Bianco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 2.2.2; DescrizioneElementoTecnico: Infissi orizzontali
Pset Descrizione Entità - Descrizione_Entità: Struttura controsoffitto
Pset RIF_Crono - RIF_CRONO: M07S24G50
Pset RIF_EPU - RIF_EPU: CIV.SO.43
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Profilo_controsoffitto_angolo_interno_90 : Profilo controsoffitto (5)
In: A-03- sale operatorie
Type - Material: Profilo soffitto Bianco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 2.2.2; DescrizioneElementoTecnico: Infissi orizzontali
Pset Descrizione Entità - Descrizione_Entità: Struttura controsoffitto
Pset RIF_Crono - RIF_CRONO: M07S24G50
Pset RIF_EPU - RIF_EPU: CIV.SO.43
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Sguscia PVC : Sguscia PVC (207)
In: A-03- sale operatorie
Type - Material: PVC Pavimento iQ Granit SD 3096710 - Bianco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.2.1; DescrizioneElementoTecnico: Solai
Pset Descrizione Entità - Descrizione_Entità: Sguscia in PVC
Pset RIF_Crono - RIF_CRONO: M05S19G30
Pset RIF_EPU - RIF_EPU: B45242
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Sguscia PVC angolo 135° interno : Sguscia PVC (46)
In: A-03- sale operatorie
Type - Material: PVC Pavimento iQ Granit SD 3096710 - Bianco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.2.1; DescrizioneElementoTecnico: Solai
Pset Descrizione Entità - Descrizione_Entità: Sguscia in PVC
Pset RIF_Crono - RIF_CRONO: M05S19G30
Pset RIF_EPU - RIF_EPU: B45242
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Sguscia PVC angolo 90° esterno : Sguscia PVC (4)
In: A-03- sale operatorie
Type - Material: PVC Pavimento iQ Granit SD 3096710 - Bianco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.2.1; DescrizioneElementoTecnico: Solai
Pset Descrizione Entità - Descrizione_Entità: Sguscia in PVC
Pset RIF_Crono - RIF_CRONO: M05S19G30
Pset RIF_EPU - RIF_EPU: B45242
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Sguscia PVC angolo 90° interno : Sguscia PVC (5)
In: A-03- sale operatorie
Type - Material: PVC Pavimento iQ Granit SD 3096710 - Bianco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.2.1; DescrizioneElementoTecnico: Solai
Pset Descrizione Entità - Descrizione_Entità: Sguscia in PVC
Pset RIF_Crono - RIF_CRONO: M05S19G30
Pset RIF_EPU - RIF_EPU: B45242
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Squadretta_controsoffitto_angolo_135 : Squadretta angolo 135 (46)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 2.2.2; DescrizioneElementoTecnico: Infissi orizzontali
Pset Descrizione Entità - Descrizione_Entità: Struttura controsoffitto
Pset RIF_Crono - RIF_CRONO: M07S24G50
Pset RIF_EPU - RIF_EPU: CIV.17
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Squadretta_controsoffitto_angolo_90 : Squadretta angolo 90 (9)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 2.2.2; DescrizioneElementoTecnico: Infissi orizzontali
Pset Descrizione Entità - Descrizione_Entità: Struttura controsoffitto
Pset RIF_Crono - RIF_CRONO: M07S24G50
Pset RIF_EPU - RIF_EPU: CIV.17
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Staffa_supporto_prese_gas : Staffa_supporto_gas (52)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Staffa per prese del gas
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.17
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Stampato_sguscia : Stampato sguscia EU (166)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.2.1; DescrizioneElementoTecnico: Solai
Pset Descrizione Entità - Descrizione_Entità: Stampato sguscia
Pset RIF_Crono - RIF_CRONO: M05S19G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Stampato_sguscia : Stampato_sguscia (18)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.2.1; DescrizioneElementoTecnico: Solai
Pset Descrizione Entità - Descrizione_Entità: Stampato sguscia
Pset RIF_Crono - RIF_CRONO: M05S19G30
Pset RIF_EPU - RIF_EPU: CIV.SO.01
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Supporto_prese_gas : Supporto prese gas (26)
In: A-03- sale operatorie
Type - Material: <Unnamed>
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Supporto prese del gas
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.17
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : Visiva_porta : Visiva per porta complanare all'anta, 220x800mm (6)
In: A-03- sale operatorie
Type - Material: Gomma, Nero, Vetro
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.2; DescrizioneElementoTecnico: Infissi interni verticali
Pset Descrizione Entità - Descrizione_Entità: Visiva per porta
Pset RIF_Crono - RIF_CRONO: M10S36G10
Pset RIF_EPU - RIF_EPU: CIV.SO.28
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcBuildingElementProxy: Modelli generici : anta_porta_1 : Anta_porta (6)
In: A-03- sale operatorie
Type - Material: Alluminio anodizzato, HPL Abet 410
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.2; DescrizioneElementoTecnico: Infissi interni verticali
Pset Descrizione Entità - Descrizione_Entità: Anta Porta
Pset RIF_Crono - RIF_CRONO: M10S36G10
Pset RIF_EPU - RIF_EPU: CIV.SO.26
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcCovering: Controsoffitti : Controsoffitto composto : Controsoffitto isp HQ in acc prev sp 0,5mm dim 600x600mm (6)
In: A-03- sale operatorie
Type - PredefinedType: CEILING
Material: Controsoffitto Guerrasio 600x600
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 2.2.2; DescrizioneElementoTecnico: Infissi orizzontali
Pset Descrizione Entità - Descrizione_Entità: Controsoffitto metallico a tenuta
Pset RIF_Crono - RIF_CRONO: M07S24G50
Pset RIF_EPU - RIF_EPU: CIV.17
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcCurtainWall: Muri : Facciata continua : Rivest Acc Zinc Colam con film PVC antibat. bianco sp 0,8mm, 18 mm ctg (32)
In: A-03- sale operatorie
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Struttura Parete
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.43
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcDoor: Modelli generici : anta_porta_1 : Anta_porta
In: A-03- sale operatorie
Type - PredefinedType: DOOR; Material: Alluminio anodizzato, HPL Abet 410
OverallHeight: 424 mm; OverallWidth: 3352 mm
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.2; DescrizioneElementoTecnico: Infissi interni verticali
Pset Descrizione Entità - Descrizione_Entità: Anta Porta
Pset RIF_Crono - RIF_CRONO: M10S36G10
Pset RIF_EPU - RIF_EPU: CIV.SO.26
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcFurniture: Arredi : Armadio_incasso : Armadio ad incasso anta cieca in acc inox 1000x450 H2000mm (18)
In: A-03- sale operatorie
Type - Material: Acciaio, Galvanizzato, Acciaio INOX Schotch Brite, Acciaio inox AISI 304
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 7.1.1; DescrizioneElementoTecnico: Pareti contenitore
Pset Descrizione Entità - Descrizione_Entità: Armadio a Incasso
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.45
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcFurniture: Arredi : Passaferri_singola : Finestra passaferri in acc inox, mov. man 900x150 H1400mm (6)
In: A-03- sale operatorie
Type - Material: Acciaio, Galvanizzato, Acciaio INOX Schotch Brite, Vetro
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.2; DescrizioneElementoTecnico: Infissi interni verticali
Pset Descrizione Entità - Descrizione_Entità: Finestra passaferri
Pset RIF_Crono - RIF_CRONO: M05S15G30
Pset RIF_EPU - RIF_EPU: CIV.SO.47
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcFurniture: Arredi : Passbox : Tunnel passasporco sempl interbloc, acc inox, 800x500 H1000mm (6)
In: A-03- sale operatorie
Type - Material: Acciaio, Galvanizzato, Acciaio INOX Schotch Brite
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1; DescrizioneElementoTecnico: Pareti interne verticali
Pset Descrizione Entità - Descrizione_Entità: Tunnel Passbox
Pset RIF_Crono - RIF_CRONO: M10S36G10
Pset RIF_EPU - RIF_EPU: CIV.SO.44
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03

# IfcLightFixture: Apparecchi per illuminazione : Strip_Led_porta : Strip_Led_porta
In: A-03- sale operatorie
Type - Material: Plexiglass - Strip LED
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.2; DescrizioneElementoTecnico: Infissi interni verticali
Pset Descrizione Entità - Descrizione_Entità: Dettaglio Porta
Pset RIF_Crono - RIF_CRONO: M10S36G10
Pset RIF_EPU - RIF_EPU: CIV.SO.26

# IfcOpeningElement (7)
In: A-03- sale operatorie
PredefinedType: OPENING
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.2; DescrizioneElementoTecnico: Infissi interni verticali
Pset Descrizione Entità - Descrizione_Entità: Anta Porta
Pset RIF_Crono - RIF_CRONO: M10S36G10
Pset RIF_EPU - RIF_EPU: CIV.SO.26
Pset WBS - WBS_01: DBE; WBS_02: ARC; WBS_03: P03
