Properties of the parts of a building model (IFC4), part 3 of 6

# IfcDistributionPort (3120)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1473132_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473152_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473138_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473134_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473134_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673032_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473141_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473136_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473136_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1672994_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473139_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473138_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473160_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473139_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473153_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473141_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473146_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473142_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473142_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473156_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473144_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473152_3 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473156_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473144_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473147_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473146_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473149_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473147_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473354_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473149_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473152_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473153_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673032_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473261_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473261_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673088_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473274_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673094_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1673098_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473274_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672994_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473320_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473320_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673365_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1672960_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473354_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473365_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1672960_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1673211_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473365_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473472_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473434_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1673094_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473460_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473460_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473472_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473816_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473820_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473817_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473818_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473818_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473850_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473820_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473848_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473848_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473822_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473822_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473842_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473828_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473824_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473824_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1481180_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1473826_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473831_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473826_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1480950_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473829_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473828_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473850_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473829_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1473831_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473843_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473832_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473836_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473846_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473832_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473842_3 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473834_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473834_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473846_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473836_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473837_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473837_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473839_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473839_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473837_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473840_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473839_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1480964_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473840_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1473842_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473843_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473938_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473942_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473939_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473940_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473940_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473972_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473942_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473970_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473970_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473944_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473944_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473964_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473950_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1476062_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473951_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473950_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473972_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473951_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473953_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1476037_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473965_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473953_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473958_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473954_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473954_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473968_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473956_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473964_3 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473968_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473956_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473959_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473958_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473961_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473959_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476013_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473961_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473964_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473965_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1481180_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1474034_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1474034_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489903_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1474059_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1480950_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1474059_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489953_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1474096_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1480964_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489986_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1474096_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489750_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476013_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476037_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1489803_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1476062_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489846_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1476256_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476284_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488667_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476256_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476258_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 1
OutPort_1477149_6 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 1
InPort_1476260_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 16
OutPort_1476258_6 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 16
InPort_1485126_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
OutPort_1476258_7 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
InPort_1485332_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1476258_8 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1485474_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1476258_9 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1476259_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 1
OutPort_1476708_6 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 1
InPort_1476264_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476259_6 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1484554_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
OutPort_1476259_7 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
InPort_1484690_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
OutPort_1476259_8 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
InPort_1484786_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
OutPort_1476259_9 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
InPort_1476262_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 16
OutPort_1476260_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 16
InPort_1476268_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476264_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476266_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476268_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476284_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476266_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476499_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1476272_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1476272_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1476273_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1476273_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1488032_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1476483_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1476275_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1476275_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1488095_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1476278_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476470_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476280_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476278_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476279_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476280_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476282_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476279_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488258_3 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1476282_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1476470_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488675_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478326_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1476483_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1478679_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1476499_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1476708_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478201_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1484923_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
OutPort_1476708_7 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
InPort_1485077_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
OutPort_1476708_8 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
InPort_1485267_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
OutPort_1476708_9 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
InPort_1477149_5 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1477828_6 | SOURCE | PIPE | DOMESTICCOLDWATER
InPort_1483878_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
OutPort_1477149_7 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
InPort_1485603_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
OutPort_1477149_8 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
InPort_1485578_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
OutPort_1477149_9 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
InPort_1477828_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1478636_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1483776_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
OutPort_1477828_7 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
InPort_1483791_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
OutPort_1477828_8 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
InPort_1485374_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
OutPort_1477828_9 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
InPort_1478201_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478358_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1478318_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478326_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1478358_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478318_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1478636_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1478705_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1478673_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1478679_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1478705_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1478673_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1478956_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478982_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488486_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478956_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478958_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 18
OutPort_1478991_6 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 18
InPort_1478960_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 19
OutPort_1478958_6 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 19
InPort_1486693_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
OutPort_1478958_7 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
InPort_1486720_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
OutPort_1478958_8 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
InPort_1485913_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
OutPort_1478958_9 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
InPort_1485892_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
OutPort_1478958_10 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
InPort_1478959_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 16
OutPort_1478990_6 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 16
InPort_1478964_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478959_6 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1486869_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
OutPort_1478959_7 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
InPort_1487673_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
OutPort_1478959_8 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
InPort_1478962_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 19
OutPort_1478960_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 19
InPort_1478968_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478964_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478966_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478968_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478982_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478966_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478988_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1478970_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1478970_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1478971_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1478971_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1488030_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1478986_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478973_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1478973_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478974_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1478974_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1488088_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1478976_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478984_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478978_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478976_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478977_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478978_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478980_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478977_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488256_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1478980_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478984_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488494_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1478999_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478986_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1479007_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1478988_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1478990_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478995_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1489137_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
OutPort_1478990_7 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
InPort_1489139_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
OutPort_1478990_8 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
InPort_1489141_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
OutPort_1478990_9 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
InPort_1478991_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1479345_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1485868_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
OutPort_1478991_7 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
InPort_1487362_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
OutPort_1478991_8 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
InPort_1487383_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
OutPort_1478991_9 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
InPort_1478995_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1479001_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1478997_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478999_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1479001_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1478997_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1479005_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1479007_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1479009_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1479005_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1479345_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1479009_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1479516_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
OutPort_1484978_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
InPort_1479517_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
OutPort_1482831_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
InPort_1485510_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
OutPort_1479524_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
InPort_1479524_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
OutPort_1485514_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
InPort_1479564_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
OutPort_1484843_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
InPort_1479565_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1482798_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1485487_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1479572_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1479572_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1485491_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1479592_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
OutPort_1484880_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
InPort_1479593_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1482726_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1485345_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1479600_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1479600_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1485349_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1479622_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
OutPort_1482638_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
InPort_1479623_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
OutPort_1482669_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
InPort_1484642_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
OutPort_1479628_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
InPort_1479628_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
OutPort_1484646_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
InPort_1485162_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
OutPort_1479630_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
InPort_1479630_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
OutPort_1485166_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
InPort_1479652_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
OutPort_1483169_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
InPort_1479653_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
OutPort_1483136_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
InPort_1487714_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
OutPort_1479658_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
InPort_1479658_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
OutPort_1487718_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
InPort_1486826_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
OutPort_1479660_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
InPort_1479660_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
OutPort_1486830_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
InPort_1479682_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
OutPort_1483233_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
InPort_1479683_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
OutPort_1483203_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
InPort_1483235_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
OutPort_1479688_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
InPort_1479688_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
OutPort_1487675_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
InPort_1486805_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
OutPort_1479690_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
InPort_1479690_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
OutPort_1486809_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
InPort_1479710_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
OutPort_1487555_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
InPort_1479711_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
OutPort_1483264_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
InPort_1486784_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
OutPort_1479718_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
InPort_1479718_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
OutPort_1486788_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
InPort_1479738_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
OutPort_1482889_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
InPort_1479739_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
OutPort_1482917_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
InPort_1482891_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
OutPort_1479744_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
InPort_1479744_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
OutPort_1485090_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
InPort_1482919_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
OutPort_1479746_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
InPort_1479746_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
OutPort_1485635_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
InPort_1479768_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
OutPort_1482948_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
InPort_1479769_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
OutPort_1482977_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
InPort_1485675_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
OutPort_1479776_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
InPort_1479776_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
OutPort_1485716_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
InPort_1479796_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
OutPort_1483016_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
InPort_1479797_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
OutPort_1483043_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
InPort_1483018_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
OutPort_1479802_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
InPort_1479802_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
OutPort_1487816_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
InPort_1479824_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
OutPort_1483074_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
InPort_1479825_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
OutPort_1483103_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
InPort_1483076_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
OutPort_1479830_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
InPort_1479830_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
OutPort_1487852_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
InPort_1479913_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
OutPort_1483327_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
InPort_1486735_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
OutPort_1479916_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
InPort_1479916_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
OutPort_1486739_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
InPort_1479931_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
OutPort_1483361_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
InPort_1483363_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
OutPort_1479934_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
InPort_1479934_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
OutPort_1486695_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
InPort_1493061_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1480307_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1480307_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1493065_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1480350_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1493029_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1493033_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1480350_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1480386_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1492983_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1492987_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1480386_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1480531_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1493841_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1480531_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1493843_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1480535_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1493870_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1493545_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1480535_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1480623_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489741_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1480676_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489794_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1489837_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1480704_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489903_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1481191_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1481191_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489905_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1481217_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489953_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1481217_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489955_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1481319_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489986_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489988_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1481319_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1481932_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1495593_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1482161_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1481932_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1495573_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1481968_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1481968_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1482188_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1495556_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1481999_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1481999_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1482228_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1482159_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1482161_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1482163_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1482159_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1492188_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1482163_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1482188_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1482186_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1482186_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1482190_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1482190_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1492144_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1482228_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1482226_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1482226_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1482230_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1482230_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1492122_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1482332_3 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1482330_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1482330_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1493061_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1493346_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1482332_4 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1482332_5 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1482333_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1482333_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1492307_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1482366_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1482368_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1493029_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1482366_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1482369_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1482368_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1482368_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1490088_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1492293_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1482369_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1482396_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1482398_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1492983_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1482396_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1482399_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1482398_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1482398_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1490081_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1492291_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1482399_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1482638_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
OutPort_1484642_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
InPort_1482669_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
OutPort_1485162_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
InPort_1482726_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1485345_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1482798_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1485487_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1482831_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
OutPort_1485510_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
InPort_1482889_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
OutPort_1482891_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
InPort_1482917_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
OutPort_1482919_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
InPort_1482948_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
OutPort_1482950_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
InPort_1482950_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
OutPort_1485276_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
InPort_1482977_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
OutPort_1485675_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
InPort_1483016_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
OutPort_1483018_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
InPort_1483043_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
OutPort_1483045_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
InPort_1483045_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
OutPort_1487460_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
InPort_1483074_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
OutPort_1483076_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
InPort_1483103_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
OutPort_1483105_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
InPort_1483105_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
OutPort_1487401_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
InPort_1483136_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
OutPort_1486826_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
InPort_1483169_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
OutPort_1487714_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
InPort_1483203_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
OutPort_1486805_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
InPort_1483233_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
OutPort_1483235_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
InPort_1483264_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
OutPort_1486784_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
InPort_1483327_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
OutPort_1486735_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
InPort_1483361_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
OutPort_1483363_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
InPort_1483493_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
OutPort_1483606_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
InPort_1485412_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
OutPort_1483494_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
InPort_1483494_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
OutPort_1485416_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
InPort_1483606_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
OutPort_1485412_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
InPort_1483629_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
OutPort_1483632_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
InPort_1485433_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
OutPort_1483630_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
InPort_1483630_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
OutPort_1485437_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
InPort_1483632_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
OutPort_1485433_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
InPort_1483647_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
OutPort_1483650_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
InPort_1485387_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
OutPort_1483648_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
InPort_1483648_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
OutPort_1485391_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
InPort_1483650_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
OutPort_1485387_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
InPort_1483745_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
OutPort_1483776_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
InPort_1485437_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
OutPort_1483745_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 36
InPort_1483779_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
OutPort_1483791_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
InPort_1485416_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
OutPort_1483779_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 34
InPort_1483805_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
OutPort_1485374_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
InPort_1485391_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
OutPort_1483805_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 37
InPort_1483826_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
OutPort_1485578_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
InPort_1485714_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
OutPort_1483826_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
InPort_1483847_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
OutPort_1485603_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
InPort_1485633_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
OutPort_1483847_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
InPort_1483868_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
OutPort_1483878_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
InPort_1485514_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
OutPort_1483868_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 21
InPort_1483892_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1485474_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1485491_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1483892_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1483918_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1485332_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1485349_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
OutPort_1483918_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 9
InPort_1483942_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
OutPort_1485126_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
InPort_1485166_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
OutPort_1483942_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 15
InPort_1483996_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
OutPort_1484554_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
InPort_1484646_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
OutPort_1483996_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 14
InPort_1484035_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
OutPort_1484690_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
InPort_1484886_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
OutPort_1484035_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
InPort_1484060_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
OutPort_1484923_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
InPort_1484984_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
OutPort_1484060_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
InPort_1484081_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
OutPort_1485077_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
InPort_1485088_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
OutPort_1484081_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
InPort_1484506_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
OutPort_1484786_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
InPort_1484849_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
OutPort_1484506_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
InPort_1484845_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
OutPort_1484833_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
InPort_1484833_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
OutPort_1484849_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
InPort_1484843_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
OutPort_1484845_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 18
InPort_1484882_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
OutPort_1484868_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
InPort_1484868_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
OutPort_1484886_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
InPort_1484880_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
OutPort_1484882_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 6
InPort_1484980_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
OutPort_1484962_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
InPort_1484962_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
OutPort_1484984_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
InPort_1484978_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
OutPort_1484980_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 17
InPort_1485080_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
OutPort_1485088_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
InPort_1485090_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
OutPort_1485080_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 25
InPort_1485294_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
OutPort_1485267_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
InPort_1485276_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
OutPort_1485291_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
InPort_1485291_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
OutPort_1485285_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
InPort_1485285_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
OutPort_1485309_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
InPort_1485309_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
OutPort_1485294_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 26
InPort_1485625_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
OutPort_1485633_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
InPort_1485635_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
OutPort_1485625_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 28
InPort_1485706_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
OutPort_1485714_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
InPort_1485716_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
OutPort_1485706_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 29
InPort_1485814_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
OutPort_1487383_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
InPort_1487398_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
OutPort_1485814_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
InPort_1485835_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
OutPort_1487362_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
InPort_1487457_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
OutPort_1485835_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
InPort_1485858_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
OutPort_1485868_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
InPort_1486830_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
OutPort_1485858_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 25
InPort_1485882_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
OutPort_1485892_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
InPort_1486809_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
OutPort_1485882_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 26
InPort_1485903_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
OutPort_1485913_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
InPort_1486788_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
OutPort_1485903_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 27
InPort_1485924_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
