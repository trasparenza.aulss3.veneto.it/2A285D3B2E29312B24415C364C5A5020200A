Properties of the parts of a building model (IFC4), part 5 of 6

# IfcDistributionPort (3120)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_1724393_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724375_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724397_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1724797_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1724862_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1724836_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1724846_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1724866_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1724836_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1724862_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1724848_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1724848_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1724866_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7

# IfcDistributionSystem: Acqua calda sanitaria (27)
PredefinedType: DOMESTICHOTWATER
Name
Acqua calda sanitaria 7
Acqua calda sanitaria 5
Acqua calda sanitaria 4
Acqua calda sanitaria 3
Acqua calda sanitaria 2
Acqua calda sanitaria 8
Acqua calda sanitaria 9
Acqua calda sanitaria 11
Acqua calda sanitaria 10
Acqua calda sanitaria 12
Acqua calda sanitaria 13
Acqua calda sanitaria 1
Acqua calda sanitaria 14
Acqua calda sanitaria 6
Acqua calda sanitaria 18
Acqua calda sanitaria 17
Acqua calda sanitaria 25
Acqua calda sanitaria 26
Acqua calda sanitaria 16
Acqua calda sanitaria 24
Acqua calda sanitaria 23
Acqua calda sanitaria 22
Acqua calda sanitaria 27
Acqua calda sanitaria 28
Acqua calda sanitaria 19
Acqua calda sanitaria 15
Acqua calda sanitaria 20

# IfcDistributionSystem: Acqua fredda sanitaria (32)
PredefinedType: DOMESTICCOLDWATER
Name
Acqua fredda sanitaria 7
Acqua fredda sanitaria 6
Acqua fredda sanitaria 5
Acqua fredda sanitaria 4
Acqua fredda sanitaria 8
Acqua fredda sanitaria 3
Acqua fredda sanitaria 2
Acqua fredda sanitaria 10
Acqua fredda sanitaria 13
Acqua fredda sanitaria 12
Acqua fredda sanitaria 11
Acqua fredda sanitaria 14
Acqua fredda sanitaria 1
Acqua fredda sanitaria 16
Acqua fredda sanitaria 15
Acqua fredda sanitaria 9
Acqua fredda sanitaria 21
Acqua fredda sanitaria 28
Acqua fredda sanitaria 29
Acqua fredda sanitaria 36
Acqua fredda sanitaria 34
Acqua fredda sanitaria 37
Acqua fredda sanitaria 18
Acqua fredda sanitaria 19
Acqua fredda sanitaria 33
Acqua fredda sanitaria 32
Acqua fredda sanitaria 27
Acqua fredda sanitaria 26
Acqua fredda sanitaria 25
Acqua fredda sanitaria 30
Acqua fredda sanitaria 31
Acqua fredda sanitaria 17

# IfcDistributionSystem: Acqua osmotizzata, Acqua osmotizzata 1
PredefinedType: DOMESTICCOLDWATER

# IfcDistributionSystem: Antincendio (2)
PredefinedType: USERDEFINED
Name
Antincendio 2
Antincendio 3

# IfcDistributionSystem: Mandata sistema idronico, Mandata sistema idronico 1
PredefinedType: HEATING

# IfcDistributionSystem: Ricircolo acqua calda sanitaria, Ricircolo acqua calda sanitaria 4
PredefinedType: DOMESTICHOTWATER

# IfcDistributionSystem: Ritorno sistema idronico, Ritorno sistema idronico 1 (1)
PredefinedType: HEATING

# IfcDistributionSystem: Scarichi acque nere (44)
PredefinedType: SEWAGE
Name
Scarichi acque nere 1
Scarichi acque nere 2
Scarichi acque nere 4
Scarichi acque nere 3
Scarichi acque nere 6
Scarichi acque nere 5
Scarichi acque nere 8
Scarichi acque nere 7
Scarichi acque nere 10
Scarichi acque nere 9
Scarichi acque nere 12
Scarichi acque nere 11
Scarichi acque nere 14
Scarichi acque nere 13
Scarichi acque nere 17
Scarichi acque nere 15
Scarichi acque nere 19
Scarichi acque nere 16
Scarichi acque nere 21
Scarichi acque nere 18
Scarichi acque nere 23
Scarichi acque nere 20
Scarichi acque nere 25
Scarichi acque nere 22
Scarichi acque nere 26
Scarichi acque nere 24
Scarichi acque nere 28
Scarichi acque nere 30
Scarichi acque nere 31
Scarichi acque nere 38
Scarichi acque nere 39
Scarichi acque nere 36
Scarichi acque nere 35
Scarichi acque nere 27
Scarichi acque nere 29
Scarichi acque nere 37
Scarichi acque nere 32
Scarichi acque nere 33
Scarichi acque nere 34
Scarichi acque nere 44
Scarichi acque nere 43
Scarichi acque nere 41
Scarichi acque nere 42
Scarichi acque nere 40

# IfcDistributionSystem: Ventilazione scarichi acque nere (2)
PredefinedType: SEWAGE
Name
Ventilazione scarichi acque nere 1
Ventilazione scarichi acque nere 2

# IfcFireSuppressionTerminal: Attrezzatura meccanica : Estintore : Estintore (8)
In: A-03-FIN
Type - Material: Color RGB 045-045-045, Color RAL 3000, Color RGB 145-145-145, Color RGB 187-185-183
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset Main Mechanical Data - Main Mechanical Data: A polvere - 6 kg
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.01.12.01
Pset Main Dimensions - Main Dimensions: 600x150mm
Abaco IFCGUID - Famiglia e tipo: Estintore: Estintore

# IfcFireSuppressionTerminal: Attrezzatura meccanica : Estintore CO2 : Estintore CO2 (2)
In: A-03-FIN
Type - Material: Color RGB 045-045-045, Color RAL 3000, Color RGB 145-145-145, Color RGB 187-185-183
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset Main Mechanical Data - Main Mechanical Data: Ad anidride carbonica - 5 kg
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.01.13.02
Pset Main Dimensions - Main Dimensions: 600x150mm
Abaco IFCGUID - Famiglia e tipo: Estintore CO2: Estintore CO2

# IfcFireSuppressionTerminal: Attrezzatura meccanica : Idrante UNI45 : Idrante UNI45 (6)
In: A-03-FIN
Type - Material: AB_RAL9010_White, AB_RAL3000_Red (3), AB_RAL9011_Graphite black, AB_Hose White, AB_Steel
Classification: D4030 Uniformat (Uniformat); Material: AB_RAL9010_White, AB_RAL3000_Red, AB_RAL9011_Graphite black, AB_Hose White, AB_Steel
Pset Descrizione_Entità - Descrizione_Entità: Idrante a muro CE DN45 20m starjet F13
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.3
Pset Main Mechanical Data - Main Mechanical Data: Da incasso DN 45 UNI EN 671/2 Manichetta L=25m
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.01.12.01
Pset Main Dimensions - Main Dimensions: 375x200x600mm
Abaco IFCGUID - Famiglia e tipo: Idrante UNI45: Idrante UNI45
Name (Attrezzatura meccanica : Idrante UNI45 :...) | Group
3 x  Idrante UNI45 | Antincendio 2
3 x  Idrante UNI45 | Antincendio 3

# IfcPipeFitting: Raccordi tubazione : Acciaio, filettato - Curva corta, FF, ISO/EN D1 : DN8-DN100 (90°), DN15-DN50 (15°-30°) , Zincato (29)
In: A-03-FIN
Type - PredefinedType: BEND; Classification: 6.1.3 (Default Classification); Material: Acciaio, zincato
Pset Descrizione_Entità - Descrizione_Entità: Curva tubazione acciaio zincato
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.3
Pset Main Mechanical Data - Main Mechanical Data: Curva di raccordo - Acciaio Zincato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.42.01
Abaco IFCGUID - Famiglia e tipo: Acciaio, filettato - Curva corta, FF, ISO/EN D1: DN8-DN100 (90°), DN15-DN50 (15°-30°) , Zincato
Name (Raccordi tubazione : Acciaio, filettato - Curva corta, FF, ISO/EN D1 :...) | Main Dimensions | Group
8 x  DN8-DN100 (90°), DN15-DN50 (15°-30°) , Zincato | 40-40mm | Antincendio 2
2 x  DN8-DN100 (90°), DN15-DN50 (15°-30°) , Zincato | 65-65mm | Antincendio 2
6 x  DN8-DN100 (90°), DN15-DN50 (15°-30°) , Zincato | 50-50mm | Antincendio 2
 DN8-DN100 (90°), DN15-DN50 (15°-30°) , Zincato | 65-65mm | Antincendio 3
10 x  DN8-DN100 (90°), DN15-DN50 (15°-30°) , Zincato | 40-40mm | Antincendio 3
2 x  DN8-DN100 (90°), DN15-DN50 (15°-30°) , Zincato | 50-50mm | Antincendio 3

# IfcPipeFitting: Raccordi tubazione : Acciaio, filettato - Manicotto, ridotto, FF, ISO/EN M2 : DN6 - DN100, Zincato (8)
In: A-03-FIN
Type - PredefinedType: CONNECTOR; Classification: 6.1.3 (Default Classification); Material: Acciaio, zincato
Pset Descrizione_Entità - Descrizione_Entità: Manicotto ridotto
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.3
Pset Main Mechanical Data - Main Mechanical Data: Riduzione - Acciaio zincato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.42.01
Abaco IFCGUID - Famiglia e tipo: Acciaio, filettato - Manicotto, ridotto, FF, ISO/EN M2: DN6 - DN100, Zincato
Name (Raccordi tubazione : Acciaio, filettato - Manicotto, ridotto, FF, ISO/EN M2 :...) | Main Dimensions | Group
 DN6 - DN100, Zincato | 65-40mm | Antincendio 2
 DN6 - DN100, Zincato | 65-50mm | Antincendio 2
2 x  DN6 - DN100, Zincato | 50-40mm | Antincendio 2
 DN6 - DN100, Zincato | 65-40mm | Antincendio 3
2 x  DN6 - DN100, Zincato | 50-40mm | Antincendio 3
 DN6 - DN100, Zincato | 65-50mm | Antincendio 3

# IfcPipeFitting: Raccordi tubazione : Acciaio, filettato - Tee, uguale, FFF, ISO/EN B1 : DN10-DN50 (45°), DN6-DN100 (90°), Zincato (4)
In: A-03-FIN
Type - PredefinedType: JUNCTION; Classification: 6.1.3 (Default Classification); Material: Acciaio, zincato
Pset Descrizione_Entità - Descrizione_Entità: Raccordo a T tubazione acciaio zincato
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.3
Pset Main Mechanical Data - Main Mechanical Data: Raccordo a T - Acciaio Zincato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.42.01
Abaco IFCGUID - Famiglia e tipo: Acciaio, filettato - Tee, uguale, FFF, ISO/EN B1: DN10-DN50 (45°), DN6-DN100 (90°), Zincato
Name (Raccordi tubazione : Acciaio, filettato - Tee, uguale, FFF, ISO/EN B1 :...) | Main Dimensions | Group
 DN10-DN50 (45°), DN6-DN100 (90°), Zincato | 65-65-65mm | Antincendio 2
 DN10-DN50 (45°), DN6-DN100 (90°), Zincato | 50-50-50mm | Antincendio 3
 DN10-DN50 (45°), DN6-DN100 (90°), Zincato | 65-65-65mm | Antincendio 3
 DN10-DN50 (45°), DN6-DN100 (90°), Zincato | 50-50-50mm | Antincendio 2

# IfcPipeFitting: Raccordi tubazione : HDPE_Braga : Standard (36)
Type - PredefinedType: TRANSITION; Classification: 5.3.1 (Default Classification); Material: PP - Black
Pset Descrizione_Entità - Descrizione_Entità: Braga tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Raccordo a T - Polietilene alta densità
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.03.33.02-03-05-07
Abaco IFCGUID - Famiglia e tipo: HDPE_Braga: Standard
Name (Raccordi tubazione : HDPE_Braga :...) | In | Main Dimensions | Group
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 1 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 2; Scarichi acque nere 4 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 3; Scarichi acque nere 6 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 5; Scarichi acque nere 8 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 7; Scarichi acque nere 10 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 9; Scarichi acque nere 12 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 11; Scarichi acque nere 14 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 13; Scarichi acque nere 17 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 15; Scarichi acque nere 19 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 16; Scarichi acque nere 21 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 18; Scarichi acque nere 23 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 20; Scarichi acque nere 25 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 22; Scarichi acque nere 26 | AB_ProperySet - IFC_Descriptions: Colonna scarico esistente
 Standard | A-TR-FIN | D110/D110-88°30' | Scarichi acque nere 27; Scarichi acque nere 29
 Standard | A-03-FIN | D110/D50-45° | Scarichi acque nere 24; Scarichi acque nere 29
 Standard | A-03-FIN | D75/D50-45° | Scarichi acque nere 28
 Standard | A-03-FIN | D75/D50-45° | Scarichi acque nere 28; Scarichi acque nere 30
 Standard | A-03-FIN | D75/D50-45° | Scarichi acque nere 28; Scarichi acque nere 31
 Standard | A-03-FIN | D50/D50-45° | Scarichi acque nere 4; Scarichi acque nere 34
 Standard | A-03-FIN | D50/D50-45° | Scarichi acque nere 4; Scarichi acque nere 33
 Standard | A-03-FIN | D50/D50-45° | Scarichi acque nere 4; Scarichi acque nere 32
3 x  Standard | A-03-FIN | D110/D110-45° | Scarichi acque nere 4; Scarichi acque nere 37
 Standard | A-03-FIN | D110/D110-45° | Scarichi acque nere 38; Scarichi acque nere 37
 Standard | A-03-FIN | D50/D50-45° | Scarichi acque nere 43; Scarichi acque nere 41
 Standard | A-03-FIN | D50/D50-45° | Scarichi acque nere 44; Scarichi acque nere 41
 Standard | A-03-FIN | D110/D50-45° | Scarichi acque nere 4; Scarichi acque nere 41
 Standard | A-03-FIN | D110/D110-88°30' | Scarichi acque nere 39; Scarichi acque nere 37
 Standard | A-03-FIN | D110/D110-88°30' | Scarichi acque nere 36; Scarichi acque nere 37
 Standard | A-03-FIN | D110/D75-45° | Scarichi acque nere 4; Scarichi acque nere 28
 Standard | A-03-FIN | D50/D50-45° | Scarichi acque nere 26; Scarichi acque nere 35
 Standard | A-03-FIN | D50/D50-45° | Scarichi acque nere 26
2 x  Standard | A-03-FIN | D75/D50-45° | Scarichi acque nere 25
 Standard | A-03-FIN | D110/D110-88°30' | Scarichi acque nere 42; Scarichi acque nere 40

# IfcPipeFitting: Raccordi tubazione : HDPE_Riduzione concentrica : Standard (14)
Type - PredefinedType: TRANSITION; Classification: 5.3.1 (Default Classification); Material: PP-Black
Pset Descrizione_Entità - Descrizione_Entità: Riduzione tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Raccordo - Polietilene alta densità
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.03.33.02-03-05-07
Abaco IFCGUID - Famiglia e tipo: HDPE_Riduzione concentrica: Standard
Name (Raccordi tubazione : HDPE_Riduzione concentrica :...) | In | Main Dimensions | Group
2 x  Standard | A-03-FIN | 50-46mm | Scarichi acque nere 24
 Standard | A-03-FIN | 50-50mm | Scarichi acque nere 34
 Standard | A-03-FIN | 50-50mm | Scarichi acque nere 43
 Standard | A-03-FIN | D110/D50 | Scarichi acque nere 4
 Standard | A-03-FIN | 110-110mm | Scarichi acque nere 4
 Standard | A-03-FIN | D110/D50 | Scarichi acque nere 14
 Standard | A-03-FIN | D110/D50 | Scarichi acque nere 26
 Standard | A-03-FIN | D75/D50 | Scarichi acque nere 28
 Standard | A-TR-FIN | D110/D50 | Scarichi acque nere 10
 Standard | A-03-FIN | D110/D50 | Scarichi acque nere 8
2 x  Standard | A-03-FIN | D75/D50 | Scarichi acque nere 25
 Standard | A-TR-FIN | D110/D75 | Scarichi acque nere 25

# IfcPipeFitting: Raccordi tubazione : HDPE_curva : Standard (109)
Type - PredefinedType: BEND; Classification: 5.3.1 (Default Classification); Material: PP-Black
Pset Descrizione_Entità - Descrizione_Entità: Curva tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Curva 45 di raccordo - Polietilene alta densità
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.03.33.02-03-05-07
Abaco IFCGUID - Famiglia e tipo: HDPE_curva: Standard
Name (Raccordi tubazione : HDPE_curva :...) | In | Main Dimensions | Group
3 x  Standard | A-TR-FIN | D50/88.5° | Scarichi acque nere 24
2 x  Standard | A-03-FIN | D110/88.5° | Scarichi acque nere 29
 Standard | A-TR-FIN | D50/D45° | Scarichi acque nere 24
2 x  Standard | A-03-FIN | D50/D45° | Scarichi acque nere 24
3 x  Standard | A-03-FIN | D50/D45° | Scarichi acque nere 28
2 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 28
6 x  Standard | A-03-FIN | D110/45° | Scarichi acque nere 4
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 32
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 33
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 34
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 4
4 x  Standard | A-03-FIN | D50/D45° | Scarichi acque nere 4
 Standard | A-03-FIN | D50/D45° | Scarichi acque nere 34
 Standard | A-03-FIN | D50/D45° | Scarichi acque nere 33
 Standard | A-03-FIN | D50/D45° | Scarichi acque nere 32
2 x  Standard | A-03-FIN | D110/88.5° | Scarichi acque nere 4
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 44
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 43
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 41
3 x  Standard | A-03-FIN | D50/D45° | Scarichi acque nere 41
 Standard | A-03-FIN | D50/D45° | Scarichi acque nere 43
 Standard | A-03-FIN | D50/D45° | Scarichi acque nere 44
 Standard | A-03-FIN | D110/45° | Scarichi acque nere 38
 Standard | A-03-FIN | D110/88.5° | Scarichi acque nere 38
 Standard | A-03-FIN | D110/45° | Scarichi acque nere 37
 Standard | A-03-FIN | D110/88.5° | Scarichi acque nere 39
 Standard | A-03-FIN | D110/88.5° | Scarichi acque nere 36
 Standard | A-03-FIN | D75/45° | Scarichi acque nere 28
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 14
 Standard | A-03-FIN | D50/D45° | Scarichi acque nere 14
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 35
6 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 26
4 x  Standard | A-03-FIN | D50/D45° | Scarichi acque nere 26
7 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 25
4 x  Standard | A-03-FIN | D50/D45° | Scarichi acque nere 25
4 x  Standard | A-03-FIN | D75/45° | Scarichi acque nere 25
 Standard | A-03-FIN | D75/88.5° | Scarichi acque nere 25
 Standard | A-03-FIN | D50/D45° | Scarichi acque nere 30
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 8
2 x  Standard | A-03-FIN | D50/D45° | Scarichi acque nere 8
3 x  Standard | A-03-FIN | D50/88.5° | Scarichi acque nere 10
2 x  Standard | A-03-FIN | D50/D45° | Scarichi acque nere 10
2 x  Standard | A-03-FIN | D110/88.5° | Scarichi acque nere 42
2 x  Standard | A-03-FIN | D110/45° | Scarichi acque nere 42
 Standard | A-03-FIN | D50/D45° | Scarichi acque nere 31

# IfcPipeFitting: Raccordi tubazione : M_Gomito - Saldato - Generico1 : Standard (2)
In: A-03-FIN
Type - PredefinedType: CONNECTOR; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Gomito tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Curva di raccordo - Polietilene alta densità
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.03.33.02-03-05-07
Pset Main Dimensions - Main Dimensions: 50-50mm
Abaco IFCGUID - Famiglia e tipo: M_Gomito - Saldato - Generico1: Standard
Name (Raccordi tubazione : M_Gomito - Saldato - Generico1 :...) | Group
 Standard | Scarichi acque nere 30
 Standard | Scarichi acque nere 31

# IfcPipeFitting: Raccordi tubazione : PPR - GOMITO : INNESTO (158)
Type - PredefinedType: CONNECTOR; Classification: 5.2.5-6-7 (Default Classification); Material: PP-R (VERDE)
Pset Descrizione_Entità - Descrizione_Entità: Gomito tubazione PPR
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Abaco IFCGUID - Famiglia e tipo: PPR - GOMITO: INNESTO
Name (Raccordi tubazione : PPR - GOMITO :...) | In | WBS_01 | WBS_02 | WBS_03 | Main Mechanical Data | RIF_Crono | RIF_EPU | Main Dimensions | Group
18 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 20-20mm | Acqua calda sanitaria 7
21 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 20-20mm | Acqua fredda sanitaria 7
3 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 40-40mm | Ricircolo acqua calda sanitaria 4
3 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 50-50mm | Acqua calda sanitaria 7
3 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 50-50mm | Acqua fredda sanitaria 7
10 x  INNESTO | A-TR-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 20-20mm | Acqua calda sanitaria 7
10 x  INNESTO | A-TR-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 20-20mm | Acqua fredda sanitaria 7
36 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 20-20mm | Ricircolo acqua calda sanitaria 4
4 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 32-32mm | Acqua calda sanitaria 7
4 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 32-32mm | Acqua fredda sanitaria 7
6 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 40-40mm | Acqua fredda sanitaria 7
6 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 32-32mm | Ricircolo acqua calda sanitaria 4
6 x  INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 40-40mm | Acqua calda sanitaria 7
 INNESTO | A-03-FIN | DBE | IM | P01 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 40-40mm | Ricircolo acqua calda sanitaria 4
 INNESTO | A-03-FIN | DBE | IM | P01 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 50-50mm | Acqua calda sanitaria 7
 INNESTO | A-03-FIN | DBE | IM | P01 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 50-50mm | Acqua fredda sanitaria 7
3 x  INNESTO | A-TR-FIN | DBE | IM | P01 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 40-40mm | Ricircolo acqua calda sanitaria 4
2 x  INNESTO | A-TR-FIN | DBE | IM | P01 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 50-50mm | Acqua calda sanitaria 7
2 x  INNESTO | A-TR-FIN | DBE | IM | P01 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 50-50mm | Acqua fredda sanitaria 7
 INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 25-25mm | Acqua calda sanitaria 7
 INNESTO | A-03-FIN | DBE | IM | P03 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 25-25mm | Acqua fredda sanitaria 7
 INNESTO | A-03-FIN | DBE | IM | PC | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 25-25mm | Acqua osmotizzata 1
2 x  INNESTO | A-01-FIN | DBE | IM | P01 | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 25-25mm | Acqua osmotizzata 1
 INNESTO | A-04-FIN | DBE | IM | PC | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 25-25mm | Acqua osmotizzata 1
4 x  INNESTO | A-04-FIN | DBE | IM | PC | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 20-20mm | Acqua osmotizzata 1
 INNESTO | A-01-FIN | DBE | IM | PC | Curva di raccordo - Polipropilene | M3_S6_G75 | 015014a-b | 25-25mm | Acqua osmotizzata 1
4 x  INNESTO | A-01-FIN |  |  |  | Curva di raccordo - Polipropilene |  |  |  | Acqua osmotizzata 1
3 x  INNESTO | A-TR-FIN |  |  |  |  |  |  |  | Acqua calda sanitaria 7

# IfcPipeFitting: Raccordi tubazione : PPR - RIDUTTORE MF : BOCCOLA (23)
Type - PredefinedType: TRANSITION; Classification: 5.2.5-6-7 (Default Classification); Material: PP-R (VERDE)
Pset Descrizione_Entità - Descrizione_Entità: Riduzione tubazione PPR
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Riduzione - Polipropilene
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 015014a-b
Abaco IFCGUID - Famiglia e tipo: PPR - RIDUTTORE MF: BOCCOLA
Name (Raccordi tubazione : PPR - RIDUTTORE MF :...) | In | WBS_03 | Main Dimensions | Group
3 x  BOCCOLA | A-03-FIN | P03 | 32-20mm | Acqua calda sanitaria 7
3 x  BOCCOLA | A-03-FIN | P03 | 32-20mm | Acqua fredda sanitaria 7
 BOCCOLA | A-03-FIN | P03 | 40-32mm | Acqua calda sanitaria 7
 BOCCOLA | A-03-FIN | P03 | 40-32mm | Acqua fredda sanitaria 7
2 x  BOCCOLA | A-03-FIN | P03 | 32-20mm | Ricircolo acqua calda sanitaria 4
 BOCCOLA | A-03-FIN | P03 | 40-20mm | Acqua fredda sanitaria 7
 BOCCOLA | A-03-FIN | P03 | 40-20mm | Acqua calda sanitaria 7
 BOCCOLA | A-03-FIN | P03 | 50-40mm | Acqua fredda sanitaria 7
 BOCCOLA | A-03-FIN | P03 | 50-40mm | Acqua calda sanitaria 7
 BOCCOLA | A-03-FIN | P03 | 40-32mm | Ricircolo acqua calda sanitaria 4
 BOCCOLA | A-03-FIN | P03 | 40-20mm | Ricircolo acqua calda sanitaria 4
 BOCCOLA | A-03-FIN | P03 | 50-32mm | Acqua fredda sanitaria 7
 BOCCOLA | A-03-FIN | P03 | 50-32mm | Acqua calda sanitaria 7
 BOCCOLA | A-03-FIN | P03 | 32-25mm | Acqua calda sanitaria 7
 BOCCOLA | A-03-FIN | P03 | 32-25mm | Acqua fredda sanitaria 7
3 x  BOCCOLA | A-04-FIN | PC | 25-20mm | Acqua osmotizzata 1

# IfcPipeFitting: Raccordi tubazione : PPR - T : SDR 11 VERDE (52)
Type - PredefinedType: TRANSITION; Classification: 5.2.5-6-7 (Default Classification); Material: PP-R (VERDE)
Pset Descrizione_Entità - Descrizione_Entità: Raccordo a T tubazione PPR
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Raccordo a T - Polipropilene
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 015014a-b
Abaco IFCGUID - Famiglia e tipo: PPR - T: SDR 11 VERDE
Name (Raccordi tubazione : PPR - T :...) | In | WBS_03 | Main Dimensions | Group
2 x  SDR 11 VERDE | A-TR-FIN | P03 | 20-20-20mm | Acqua fredda sanitaria 7
2 x  SDR 11 VERDE | A-TR-FIN | P03 | 20-20-20mm | Acqua calda sanitaria 7
4 x  SDR 11 VERDE | A-03-FIN | P03 | 20-20-20mm | Ricircolo acqua calda sanitaria 4; Acqua calda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 32-32-20mm | Acqua calda sanitaria 7
6 x  SDR 11 VERDE | A-03-FIN | P03 | 20-20-20mm | Ricircolo acqua calda sanitaria 4
3 x  SDR 11 VERDE | A-03-FIN | P03 | 20-20-20mm | Acqua calda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 25-25-20mm | Acqua calda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 25-20-20mm | Acqua calda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 25-20-20mm | Acqua fredda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 32-32-32mm | Ricircolo acqua calda sanitaria 4
 SDR 11 VERDE | A-03-FIN | P03 | 40-40-40mm | Acqua calda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 40-40-40mm | Acqua fredda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 40-40-32mm | Acqua fredda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 40-40-32mm | Acqua calda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 32-32-20mm | Ricircolo acqua calda sanitaria 4
2 x  SDR 11 VERDE | A-03-FIN | P03 | 40-40-20mm | Ricircolo acqua calda sanitaria 4
2 x  SDR 11 VERDE | A-03-FIN | P03 | 50-50-20mm | Acqua calda sanitaria 7
2 x  SDR 11 VERDE | A-03-FIN | P03 | 50-50-20mm | Acqua fredda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 50-50-50mm | Acqua fredda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 50-50-50mm | Acqua calda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 40-40-40mm | Ricircolo acqua calda sanitaria 4
 SDR 11 VERDE | A-03-FIN | P03 | 32-32-32mm | Acqua fredda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 32-32-32mm | Acqua calda sanitaria 7
 SDR 11 VERDE | A-TR-FIN | P01 | 50-50-40mm | Acqua calda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 25-25-25mm | Acqua calda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 25-25-25mm | Acqua fredda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 20-20-20mm | Acqua fredda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 32-32-20mm | Acqua fredda sanitaria 7
 SDR 11 VERDE | A-03-FIN | P03 | 25-25-20mm | Acqua fredda sanitaria 7
2 x  SDR 11 VERDE | A-04-FIN | PC | 25-25-25mm | Acqua osmotizzata 1
6 x  SDR 11 VERDE | A-04-FIN | PC | 25-25-20mm | Acqua osmotizzata 1

# IfcPipeFitting: Raccordi tubazione : PPR - TAPPO a tasca : INNESTO (17)
Type - PredefinedType: OBSTRUCTION; Classification: 5.2.5-6-7 (Default Classification); Material: PP-R (VERDE)
Pset Descrizione_Entità - Descrizione_Entità: Tappo tubazione PPR
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Tappo di chiusura - Polipropilene
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 015014a-b
Abaco IFCGUID - Famiglia e tipo: PPR - TAPPO a tasca: INNESTO
Name (Raccordi tubazione : PPR - TAPPO a tasca :...) | In | WBS_03 | Main Dimensions | Group
 INNESTO | A-03-FIN | P03 | 20mm | Acqua fredda sanitaria 6
 INNESTO | A-03-FIN | P03 | 20mm | Acqua fredda sanitaria 8
 INNESTO | A-03-FIN | P03 | 20mm | Acqua fredda sanitaria 13
 INNESTO | A-03-FIN | P03 | 20mm | Acqua fredda sanitaria 16
 INNESTO | A-03-FIN | P03 | 20mm | Acqua fredda sanitaria 19
 INNESTO | A-03-FIN | P03 | 20mm | Ricircolo acqua calda sanitaria 4
 INNESTO | A-03-FIN | P03 | 25mm | Acqua calda sanitaria 7
 INNESTO | A-03-FIN | P03 | 25mm | Acqua fredda sanitaria 7
9 x  INNESTO | A-04-FIN | PC | 20mm | Acqua osmotizzata 1

# IfcPipeFitting: Raccordi tubazione : Raccordo a pressare _ gomito : Gomito-01 (111)
Type - PredefinedType: CONNECTOR; Material: RAL 9010 - Pure white - BRAVOPress®, INOX_AISI_304 - Sleeves - Valsir S.p.A., White_LDPE - Fixing_Ring - Valsir Pexal®BRASS
Pset Descrizione_Entità - Descrizione_Entità: Raccordo tubazione - gomito
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Abaco IFCGUID - Famiglia e tipo: Raccordo a pressare _ gomito: Gomito-01
Name (Raccordi tubazione : Raccordo a pressare _ gomito :...) | In | WBS_01 | WBS_02 | WBS_03 | Main Mechanical Data | RIF_Crono | RIF_EPU | Main Dimensions | Group
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 4
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 4
3 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 4
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 5
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 4
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 5
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 5
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 5
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 3
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 3
4 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 2
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 2
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 8
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 10
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 9
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 9
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 12
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 11
3 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 11
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 12
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 14
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 13
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 10
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 13
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 25
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 28
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 26
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 27
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 30
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 28
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 31
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 23
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 33
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 14
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 14
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 18
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 18
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 6
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 6
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 17
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 17
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 25
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 15
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 15
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 26
2 x  Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 9
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 9
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 37
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 37
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 34
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 34
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 36
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 36
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 21
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 21
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 28
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 29
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 29
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 33
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 32
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 32
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 27
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 27
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 26
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 26
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 25
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 25
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 31
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua fredda sanitaria 30
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 24
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 24
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 23
 Gomito-01 | A-TR-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 22
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 22
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 27
2 x  Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 28
2 x  Gomito-01 | A-TR-FIN |  |  |  | Gomito - Multistrato |  |  |  | Acqua fredda sanitaria 11
 Gomito-01 | A-03-FIN |  |  |  | Gomito - Multistrato |  |  |  | Acqua fredda sanitaria 11
 Gomito-01 | A-03-FIN | DBE | IM | P03 | Gomito - Multistrato | M3_S6_G75 | 015023a | 16-16mm | Acqua calda sanitaria 10
3 x  Gomito-01 | A-TR-FIN |  |  |  |  |  |  |  | Acqua calda sanitaria 10

# IfcPipeFitting: Raccordi tubazione : Raccordo a pressare _ raccordo riduzione : Riduzione-01 (48)
In: A-03-FIN
Type - PredefinedType: TRANSITION; Material: RAL 9010 - Pure white - BRAVOPress®, White_LDPE - Fixing_Ring - Valsir Pexal®BRASS, INOX_AISI_304 - Sleeves - Valsir S.p.A.
Pset Descrizione_Entità - Descrizione_Entità: Raccordo tubazione - riduzione
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Raccordo - Multistrato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 015023a
Pset Main Dimensions - Main Dimensions: 20-16mm
Abaco IFCGUID - Famiglia e tipo: Raccordo a pressare _ raccordo riduzione: Riduzione-01
Name (Raccordi tubazione : Raccordo a pressare _ raccordo riduzione :...) | Group
 Riduzione-01 | Acqua calda sanitaria 4
2 x  Riduzione-01 | Acqua fredda sanitaria 4
 Riduzione-01 | Acqua fredda sanitaria 5
 Riduzione-01 | Acqua calda sanitaria 5
 Riduzione-01 | Acqua calda sanitaria 8
2 x  Riduzione-01 | Acqua fredda sanitaria 2
 Riduzione-01 | Acqua fredda sanitaria 10
 Riduzione-01 | Acqua fredda sanitaria 3
 Riduzione-01 | Acqua calda sanitaria 2
 Riduzione-01 | Acqua calda sanitaria 3
 Riduzione-01 | Acqua calda sanitaria 9
 Riduzione-01 | Acqua calda sanitaria 12
2 x  Riduzione-01 | Acqua fredda sanitaria 11
 Riduzione-01 | Acqua fredda sanitaria 14
 Riduzione-01 | Acqua fredda sanitaria 12
 Riduzione-01 | Acqua calda sanitaria 10
 Riduzione-01 | Acqua calda sanitaria 11
 Riduzione-01 | Acqua calda sanitaria 13
 Riduzione-01 | Acqua fredda sanitaria 36
 Riduzione-01 | Acqua fredda sanitaria 34
 Riduzione-01 | Acqua fredda sanitaria 21
 Riduzione-01 | Acqua calda sanitaria 14
 Riduzione-01 | Acqua calda sanitaria 6
 Riduzione-01 | Acqua calda sanitaria 18
 Riduzione-01 | Acqua calda sanitaria 17
 Riduzione-01 | Acqua calda sanitaria 25
 Riduzione-01 | Acqua fredda sanitaria 15
 Riduzione-01 | Acqua calda sanitaria 26
2 x  Riduzione-01 | Acqua fredda sanitaria 9
 Riduzione-01 | Acqua fredda sanitaria 37
 Riduzione-01 | Acqua fredda sanitaria 29
 Riduzione-01 | Acqua fredda sanitaria 28
 Riduzione-01 | Acqua fredda sanitaria 25
 Riduzione-01 | Acqua fredda sanitaria 26
 Riduzione-01 | Acqua fredda sanitaria 27
 Riduzione-01 | Acqua fredda sanitaria 33
 Riduzione-01 | Acqua fredda sanitaria 32
 Riduzione-01 | Acqua calda sanitaria 24
 Riduzione-01 | Acqua fredda sanitaria 30
 Riduzione-01 | Acqua fredda sanitaria 31
 Riduzione-01 | Acqua calda sanitaria 23
 Riduzione-01 | Acqua calda sanitaria 22
 Riduzione-01 | Acqua calda sanitaria 27
 Riduzione-01 | Acqua calda sanitaria 28

# IfcPipeSegment: Tubazioni : Tubazione : Acciaio zincato, filettato - DN10-150 (46)
In: A-03-FIN
Type - PredefinedType: RIGIDSEGMENT
Classification: 6.1.3 (Default Classification)
Pset Descrizione_Entità - Descrizione_Entità: Tubazione in acciaio zincato - Idrante UNI 45
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.3
Pset Main Mechanical Data - Main Mechanical Data: Tubazione - Acciaio Zincato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.42.01
Abaco IFCGUID - Famiglia e tipo: Tubazione: Acciaio zincato, filettato - DN10-150
Name (Tubazioni : Tubazione :...) | Main Dimensions | Group
10 x  Acciaio zincato, filettato - DN10-150 | Ø40mm | Antincendio 2
5 x  Acciaio zincato, filettato - DN10-150 | Ø65mm | Antincendio 2
9 x  Acciaio zincato, filettato - DN10-150 | Ø50mm | Antincendio 2
13 x  Acciaio zincato, filettato - DN10-150 | Ø40mm | Antincendio 3
4 x  Acciaio zincato, filettato - DN10-150 | Ø65mm | Antincendio 3
5 x  Acciaio zincato, filettato - DN10-150 | Ø50mm | Antincendio 3

# IfcPipeSegment: Tubazioni : Tubazione : HDPE SDR26 (202)
In: A-03-FIN
Type - PredefinedType: RIGIDSEGMENT
Classification: 5.3.1 (Default Classification)
Pset Descrizione_Entità - Descrizione_Entità: Tubazione PE
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Tubazione in Poletilene ad alta densità
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Abaco IFCGUID - Famiglia e tipo: Tubazione: HDPE SDR26
Name (Tubazioni : Tubazione :...) | RIF_EPU | Main Dimensions | IFC_Descriptions | Group
3 x  HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 1
2 x  HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 2
2 x  HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 3
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 6
2 x  HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 5
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 8
2 x  HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 7
2 x  HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 9
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 12
2 x  HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 11
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 13
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 17
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 15
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 19
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 16
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 21
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 18
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 23
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 20
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Ventilazione scarichi acque nere 1
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Ventilazione scarichi acque nere 2
2 x  HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 22
14 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 26
7 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 24
2 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 27
4 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 29
7 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 37
14 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 4
5 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø75mm | Nuova installazione | Scarichi acque nere 28
7 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 28
3 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 30
3 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 31
5 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 32
5 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 33
5 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 34
11 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 4
3 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 38
5 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 44
5 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 43
9 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 41
2 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 36
2 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 39
5 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 14
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 14
4 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 35
 HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 26
12 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 25
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 25
9 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø75mm | Nuova installazione | Scarichi acque nere 25
5 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 42
 HDPE SDR26 | Esistente | Ø110mm | Colonna scarico esistente | Scarichi acque nere 10
6 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 8
6 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø50mm | Nuova installazione | Scarichi acque nere 10
2 x  HDPE SDR26 | VEN24-11.03.33.01-02-03-05-07 | Ø110mm | Nuova installazione | Scarichi acque nere 40

# IfcPipeSegment: Tubazioni : Tubazione : Multistrato PEX/Al/PEX (159)
Type - PredefinedType: RIGIDSEGMENT
Pset Descrizione_Entità - Descrizione_Entità: Tubazione in multistrato PEX/AI/PEX
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Tubazione - Multistrato
Abaco IFCGUID - Famiglia e tipo: Tubazione: Multistrato PEX/Al/PEX
Name (Tubazioni : Tubazione :...) | In | WBS_01 | WBS_02 | WBS_03 | RIF_Crono | RIF_EPU | Main Dimensions | Group
3 x  Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 4
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 4
3 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 4
4 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 4
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 5
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 5
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 5
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 5
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 3
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 2
4 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 2
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 3
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 10
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 9
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 10
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 8
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 9
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 8
2 x  Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 2
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 2
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 3
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 3
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 12
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 10
4 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 11
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 11
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 14
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 13
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 14
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 12
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 13
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 12
2 x  Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 10
2 x  Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 11
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 11
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 12
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 21
4 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 9
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 14
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 15
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 22
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 25
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 23
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 26
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 27
3 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 25
3 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 28
3 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 29
3 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 27
3 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 28
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 32
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 33
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 14
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 15
2 x  Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 9
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 21
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 25
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 28
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 26
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 29
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 27
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 30
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 28
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 31
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 25
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 22
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 26
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 23
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 27
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 32
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 33
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 34
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 34
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 36
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 36
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 37
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 37
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 6
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 17
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 18
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 18
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 6
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 17
3 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 26
3 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 31
