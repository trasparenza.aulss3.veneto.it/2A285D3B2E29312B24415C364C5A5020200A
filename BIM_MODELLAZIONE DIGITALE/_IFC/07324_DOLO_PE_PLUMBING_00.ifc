Properties of the parts of a building model (IFC4), part 6 of 6

# IfcPipeSegment: Tubazioni : Tubazione : Multistrato PEX/Al/PEX (159)
Name (Tubazioni : Tubazione :...) | In | WBS_01 | WBS_02 | WBS_03 | RIF_Crono | RIF_EPU | Main Dimensions | Group
3 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua fredda sanitaria 30
2 x  Multistrato PEX/Al/PEX | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 24
 Multistrato PEX/Al/PEX | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015023a | Ø16mm | Acqua calda sanitaria 24
 Multistrato PEX/Al/PEX | A-TR-FIN |  |  |  |  |  |  | Acqua fredda sanitaria 11
 Multistrato PEX/Al/PEX | A-03-FIN |  |  |  |  |  |  | Acqua fredda sanitaria 11
2 x  Multistrato PEX/Al/PEX | A-TR-FIN |  |  |  |  |  |  | Acqua calda sanitaria 10

# IfcPipeSegment: Tubazioni : Tubazione : PPR_VERDE_SDR 11 S (344)
Type - PredefinedType: RIGIDSEGMENT
Classification: 5.2.5-6-7 (Default Classification)
Pset Descrizione_Entità - Descrizione_Entità: Tubazione in PPR
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Tubazione - Polipropilene
Abaco IFCGUID - Famiglia e tipo: Tubazione: PPR_VERDE_SDR 11 S
Name (Tubazioni : Tubazione :...) | In | WBS_01 | WBS_02 | WBS_03 | RIF_Crono | RIF_EPU | Main Dimensions | Group
4 x  PPR_VERDE_SDR 11 S | A-01-FIN | DBE | IM | P01 | M3_S6_G75 | 015015b | Ø40mm | Ricircolo acqua calda sanitaria 4
4 x  PPR_VERDE_SDR 11 S | A-01-FIN | DBE | IM | P01 | M3_S6_G75 | 015015b | Ø50mm | Acqua fredda sanitaria 7
5 x  PPR_VERDE_SDR 11 S | A-01-FIN | DBE | IM | P01 | M3_S6_G75 | 015015b | Ø50mm | Acqua calda sanitaria 7
43 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Acqua calda sanitaria 7
7 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015015b | Ø40mm | Ricircolo acqua calda sanitaria 4
7 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015015b | Ø50mm | Acqua calda sanitaria 7
7 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015015b | Ø50mm | Acqua fredda sanitaria 7
74 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Ricircolo acqua calda sanitaria 4
 PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Acqua fredda sanitaria 6
44 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Acqua fredda sanitaria 7
12 x  PPR_VERDE_SDR 11 S | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Acqua fredda sanitaria 7
17 x  PPR_VERDE_SDR 11 S | A-TR-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Acqua calda sanitaria 7
 PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Acqua fredda sanitaria 8
 PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Acqua fredda sanitaria 13
5 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014b | Ø25mm | Acqua fredda sanitaria 7
5 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014b | Ø25mm | Acqua calda sanitaria 7
2 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Ricircolo acqua calda sanitaria 4; Acqua calda sanitaria 7
 PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Acqua fredda sanitaria 16
12 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015015a | Ø32mm | Acqua fredda sanitaria 7
12 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015015a | Ø32mm | Acqua calda sanitaria 7
 PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015014a | Ø20mm | Acqua fredda sanitaria 19
10 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015015a | Ø32mm | Ricircolo acqua calda sanitaria 4
10 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015015b | Ø40mm | Acqua calda sanitaria 7
10 x  PPR_VERDE_SDR 11 S | A-03-FIN | DBE | IM | P03 | M3_S6_G75 | 015015b | Ø40mm | Acqua fredda sanitaria 7
 PPR_VERDE_SDR 11 S | A-01-FIN | DBE | IM | P01 | M3_S6_G75 | 015015b | Ø40mm | Ricircolo acqua calda sanitaria 4; Acqua calda sanitaria 7
 PPR_VERDE_SDR 11 S | A-TR-FIN | DBE | IM | P00 | M3_S6_G75 | 015015a | Ø32mm | Acqua fredda sanitaria 17
 PPR_VERDE_SDR 11 S | A-TR-FIN | DBE | IM | P00 | M3_S6_G75 | 015015a | Ø32mm | Ritorno sistema idronico 1 (1); Acqua calda sanitaria 20
 PPR_VERDE_SDR 11 S | A-TR-FIN | DBE | IM | P00 | M3_S6_G75 | 015015a | Ø32mm | Acqua calda sanitaria 19
4 x  PPR_VERDE_SDR 11 S | A-01-FIN | DBE | IM | P01 | M3_S6_G75 | 015014b | Ø25mm | Acqua osmotizzata 1
3 x  PPR_VERDE_SDR 11 S | A-01-FIN | DBE | IM | PC | M3_S6_G75 | 015014b | Ø25mm | Acqua osmotizzata 1
22 x  PPR_VERDE_SDR 11 S | A-04-FIN | DBE | IM | PC | M3_S6_G75 | 015014a | Ø20mm | Acqua osmotizzata 1
11 x  PPR_VERDE_SDR 11 S | A-04-FIN | DBE | IM | PC | M3_S6_G75 | 015014b | Ø25mm | Acqua osmotizzata 1
3 x  PPR_VERDE_SDR 11 S | A-01-FIN |  |  |  |  |  |  | Acqua osmotizzata 1
2 x  PPR_VERDE_SDR 11 S | A-TR-FIN |  |  |  |  |  |  | Acqua calda sanitaria 7

# IfcSanitaryTerminal: Apparecchi idraulici : Doccia 100x80 : Doccia 100x80 (4)
In: A-03-FIN
Type - PredefinedType: SHOWER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Doccia 100x80
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.8
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset Main Dimensions - Main Dimensions: 1000x800mm
Abaco IFCGUID - Famiglia e tipo: Doccia 100x80: Doccia 100x80
Name (Apparecchi idraulici : Doccia 100x80 :...) | Group
2 x  Doccia 100x80 | Scarichi acque nere 28
 Doccia 100x80 | Scarichi acque nere 30
 Doccia 100x80 | Scarichi acque nere 31

# IfcSanitaryTerminal: Apparecchi idraulici : Lavabo 150x56 : Tipo 1 (6)
In: A-03-FIN
Type - PredefinedType: WASHHANDBASIN; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Lavabo 150x56
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.8
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset Main Dimensions - Main Dimensions: 150x56mm
Abaco IFCGUID - Famiglia e tipo: Lavabo 150x56: Tipo 1
Name (Apparecchi idraulici : Lavabo 150x56 :...) | Group
2 x  Tipo 1 | Scarichi acque nere 25
 Tipo 1 | Scarichi acque nere 35
2 x  Tipo 1 | Scarichi acque nere 26
 Tipo 1 | Scarichi acque nere 14

# IfcSanitaryTerminal: Apparecchi idraulici : Lavabo : Lavabo (3)
In: A-03-FIN
Type - PredefinedType: WASHHANDBASIN; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Lavabo
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.8
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset Main Dimensions - Main Dimensions: 500x381mm
Abaco IFCGUID - Famiglia e tipo: Lavabo: Lavabo
Name (Apparecchi idraulici : Lavabo :...) | Group
 Lavabo | Scarichi acque nere 24
 Lavabo | Scarichi acque nere 8
 Lavabo | Scarichi acque nere 10

# IfcSanitaryTerminal: Apparecchi idraulici : Rubinetto a muro : Rubinetto a muro (12)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: NBS_Concept
Pset Descrizione_Entità - Descrizione_Entità: TMV3 approved deck mounted, thermostatic clinical mixer tap featuring Insutech technology, long lever sequential operation
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset Main Dimensions - Main Dimensions: DN20
Abaco IFCGUID - Famiglia e tipo: Rubinetto a muro: Rubinetto a muro

# IfcSanitaryTerminal: Apparecchi idraulici : Rubinetto idrico Calda : Rubinetto idrico Calda (29)
In: A-TR-FIN
Type - PredefinedType: USERDEFINED; Material: INOX_AISI_304 - Sleeves - Valsir S.p.A., RAL 9010 - Pure white - BRAVOPress®
Pset Descrizione_Entità - Descrizione_Entità: Rubinetto idrico circuito caldo
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Raccordo a parete - Multistrato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 015023a
Pset Main Dimensions - Main Dimensions: 16X2-1/2"
Abaco IFCGUID - Famiglia e tipo: Rubinetto idrico Calda: Rubinetto idrico Calda
Name (Apparecchi idraulici : Rubinetto idrico Calda :...) | Group
 Rubinetto idrico Calda | Acqua calda sanitaria 4
 Rubinetto idrico Calda | Acqua calda sanitaria 5
8 x  Rubinetto idrico Calda | Acqua calda sanitaria 7
 Rubinetto idrico Calda | Acqua calda sanitaria 3
 Rubinetto idrico Calda | Acqua calda sanitaria 2
 Rubinetto idrico Calda | Acqua calda sanitaria 8
 Rubinetto idrico Calda | Acqua calda sanitaria 9
 Rubinetto idrico Calda | Acqua calda sanitaria 11
 Rubinetto idrico Calda | Acqua calda sanitaria 10
 Rubinetto idrico Calda | Acqua calda sanitaria 12
 Rubinetto idrico Calda | Acqua calda sanitaria 13
 Rubinetto idrico Calda | Acqua calda sanitaria 17
 Rubinetto idrico Calda | Acqua calda sanitaria 18
 Rubinetto idrico Calda | Acqua calda sanitaria 6
 Rubinetto idrico Calda | Acqua calda sanitaria 14
 Rubinetto idrico Calda | Acqua calda sanitaria 22
 Rubinetto idrico Calda | Acqua calda sanitaria 23
 Rubinetto idrico Calda | Acqua calda sanitaria 24
 Rubinetto idrico Calda | Acqua calda sanitaria 25
 Rubinetto idrico Calda | Acqua calda sanitaria 26
 Rubinetto idrico Calda | Acqua calda sanitaria 27
 Rubinetto idrico Calda | Acqua calda sanitaria 28

# IfcSanitaryTerminal: Apparecchi idraulici : Rubinetto idrico Fredda : Rubinetto idrico Fredda (35)
In: A-TR-FIN
Type - PredefinedType: USERDEFINED; Material: INOX_AISI_304 - Sleeves - Valsir S.p.A., RAL 9010 - Pure white - BRAVOPress®
Pset Descrizione_Entità - Descrizione_Entità: Rubinetto idrico circuito freddo
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Raccordo a parete - Multistrato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 015023a
Pset Main Dimensions - Main Dimensions: 16X2-1/2"
Abaco IFCGUID - Famiglia e tipo: Rubinetto idrico Fredda: Rubinetto idrico Fredda
Name (Apparecchi idraulici : Rubinetto idrico Fredda :...) | Group
2 x  Rubinetto idrico Fredda | Acqua fredda sanitaria 4
 Rubinetto idrico Fredda | Acqua fredda sanitaria 5
8 x  Rubinetto idrico Fredda | Acqua fredda sanitaria 7
 Rubinetto idrico Fredda | Acqua fredda sanitaria 3
2 x  Rubinetto idrico Fredda | Acqua fredda sanitaria 2
 Rubinetto idrico Fredda | Acqua fredda sanitaria 10
 Rubinetto idrico Fredda | Acqua fredda sanitaria 12
2 x  Rubinetto idrico Fredda | Acqua fredda sanitaria 11
 Rubinetto idrico Fredda | Acqua fredda sanitaria 14
 Rubinetto idrico Fredda | Acqua fredda sanitaria 21
2 x  Rubinetto idrico Fredda | Acqua fredda sanitaria 9
 Rubinetto idrico Fredda | Acqua fredda sanitaria 15
 Rubinetto idrico Fredda | Acqua fredda sanitaria 25
 Rubinetto idrico Fredda | Acqua fredda sanitaria 26
 Rubinetto idrico Fredda | Acqua fredda sanitaria 27
 Rubinetto idrico Fredda | Acqua fredda sanitaria 28
 Rubinetto idrico Fredda | Acqua fredda sanitaria 29
 Rubinetto idrico Fredda | Acqua fredda sanitaria 30
 Rubinetto idrico Fredda | Acqua fredda sanitaria 31
 Rubinetto idrico Fredda | Acqua fredda sanitaria 32
 Rubinetto idrico Fredda | Acqua fredda sanitaria 33
 Rubinetto idrico Fredda | Acqua fredda sanitaria 34
 Rubinetto idrico Fredda | Acqua fredda sanitaria 36
 Rubinetto idrico Fredda | Acqua fredda sanitaria 37

# IfcSanitaryTerminal: Apparecchi idraulici : Vuotatoio : Vuotatoio
In: A-03-FIN
Type - PredefinedType: SINK; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Vuotatoio
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset Main Dimensions - Main Dimensions: 500x350mm
Abaco IFCGUID - Famiglia e tipo: Vuotatoio: Vuotatoio
Group: Scarichi acque nere 42

# IfcSanitaryTerminal: Apparecchi idraulici : WC : Default (6)
In: A-03-FIN
Type - PredefinedType: WCSEAT; Material: Starck 3 wall-mounted toilet 252709 - starck-3-wall-mounted-toilet-252709 - White Alpin
Pset Descrizione_Entità - Descrizione_Entità: WC
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 7.1.2
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset Main Dimensions - Main Dimensions: 50xx350mm
Abaco IFCGUID - Famiglia e tipo: WC: Default
Name (Apparecchi idraulici : WC :...) | Group
2 x  Default | Scarichi acque nere 4
 Default | Scarichi acque nere 38
 Default | Scarichi acque nere 39
 Default | Scarichi acque nere 36
 Default

# IfcTank: Attrezzatura meccanica : Serbatoio Accumulo : Serbatoio Accumulo
In: A-TR-FIN
Type - PredefinedType: STORAGE; Material: Color RGB 150-150-150, Color RGB 040-040-040, Color RGB 245-245-245
Classification: D30 Uniformat (Uniformat); Group: Acqua calda sanitaria 19; Ritorno sistema idronico 1 (1); Acqua fredda sanitaria 17; Mandata sistema idronico 1; Acqua calda sanitaria 15
Pset Descrizione_Entità - Descrizione_Entità: Serbatoio di accumulo acqua
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Esistente
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: Esistente
Pset Main Dimensions - Main Dimensions: Ø990
Abaco IFCGUID - Famiglia e tipo: Serbatoio Accumulo: Serbatoio Accumulo

# IfcValve: Accessori per tubazioni : Valvola a sfera DN20 - DN32 : 20x20 (38)
Type - PredefinedType: USERDEFINED; Material: Acciaio Maniglia Rosso, Material Brass, dado
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera DN20/DN32 - 20x20
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Valvola a sfera in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.35.01
Pset Main Dimensions - Main Dimensions: DN20-32 20x20
Abaco IFCGUID - Famiglia e tipo: Valvola a sfera DN20 - DN32: 20x20
Name (Accessori per tubazioni : Valvola a sfera DN20 - DN32 :...) | In | WBS_03 | Group
9 x  20x20 | A-03-FIN | P03 | Acqua fredda sanitaria 7
9 x  20x20 | A-03-FIN | P03 | Acqua calda sanitaria 7
11 x  20x20 | A-03-FIN | P03 | Ricircolo acqua calda sanitaria 4
9 x  20x20 | A-04-FIN | PC | Acqua osmotizzata 1

# IfcValve: Accessori per tubazioni : Valvola a sfera DN20 - DN32 : 32x32 (4)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Acciaio Maniglia Rosso, Material Brass, dado
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera DN20/DN32 - 32x32
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Valvola a sfera in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.35.03
Pset Main Dimensions - Main Dimensions: DN20-32 32x32
Abaco IFCGUID - Famiglia e tipo: Valvola a sfera DN20 - DN32: 32x32
Name (Accessori per tubazioni : Valvola a sfera DN20 - DN32 :...) | Group
2 x  32x32 | Acqua fredda sanitaria 7
2 x  32x32 | Acqua calda sanitaria 7

# IfcValve: Accessori per tubazioni : Valvola a sfera DN25 : 25x25
In: A-01-FIN
Type - PredefinedType: USERDEFINED; Material: Acciaio Maniglia Rosso, Material Brass, dado
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera DN25 - 25x25
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: PC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Valvola a sfera in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.35.02
Pset Main Dimensions - Main Dimensions: DN25 25x25
Abaco IFCGUID - Famiglia e tipo: Valvola a sfera DN25: 25x25
Group: Acqua osmotizzata 1

# IfcValve: Accessori per tubazioni : Valvola di bilanciamento : DN 20 (11)
In: A-03-FIN
Type - PredefinedType: REGULATING; Material: Color RGB 156-122-90, Color RGB 35-35-35
Pset Descrizione_Entità - Descrizione_Entità: Valvola di bilanciamento DN20
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.2.5-6-7
Pset Main Mechanical Data - Main Mechanical Data: Valvola di bilanciamento in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.52.01
Pset Main Dimensions - Main Dimensions: DN20
Abaco IFCGUID - Famiglia e tipo: Valvola di bilanciamento: DN 20
Group: Ricircolo acqua calda sanitaria 4

# IfcValve: Attrezzatura meccanica : Collettore acqua calda sanitaria_2 vie : Collettore acqua calda sanitaria_2 vie (2)
In: A-03-FIN
Type - Material: Brass - Nickel, BRASS - CW617N, Plastic - Red
Pset Descrizione_Entità - Descrizione_Entità: Collettore acqua calda sanitaria 2 vie
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Collettore idrico sanitario per impianto in multistrato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.02.09.01-02-03
Pset Main Dimensions - Main Dimensions: DN20
Abaco IFCGUID - Famiglia e tipo: Collettore acqua calda sanitaria_2 vie: Collettore acqua calda sanitaria_2 vie
Name (Attrezzatura meccanica : Collettore acqua calda sanitaria_2 vie :...) | Group
 Collettore acqua calda sanitaria_2 vie | Ricircolo acqua calda sanitaria 4; Acqua calda sanitaria 7; Acqua calda sanitaria 5; Acqua calda sanitaria 4
 Collettore acqua calda sanitaria_2 vie | Ricircolo acqua calda sanitaria 4; Acqua calda sanitaria 16; Acqua calda sanitaria 24; Acqua calda sanitaria 23

# IfcValve: Attrezzatura meccanica : Collettore acqua calda sanitaria_3 vie : Collettore acqua calda sanitaria_3 vie (3)
In: A-03-FIN
Type - Material: Brass - Nickel, BRASS - CW617N, Plastic - Red
Pset Descrizione_Entità - Descrizione_Entità: Collettore acqua calda sanitaria 3 vie
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Collettore idrico sanitario per impianto in multistrato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.02.09.01-02-03
Pset Main Dimensions - Main Dimensions: DN20
Abaco IFCGUID - Famiglia e tipo: Collettore acqua calda sanitaria_3 vie: Collettore acqua calda sanitaria_3 vie
Name (Attrezzatura meccanica : Collettore acqua calda sanitaria_3 vie :...) | Group
 Collettore acqua calda sanitaria_3 vie | Ricircolo acqua calda sanitaria 4; Acqua calda sanitaria 1; Acqua calda sanitaria 14; Acqua calda sanitaria 6; Acqua calda sanitaria 18
 Collettore acqua calda sanitaria_3 vie | Acqua calda sanitaria 7; Acqua calda sanitaria 1; Acqua calda sanitaria 17; Acqua calda sanitaria 25; Acqua calda sanitaria 26
 Collettore acqua calda sanitaria_3 vie | Acqua calda sanitaria 7; Acqua calda sanitaria 16; Acqua calda sanitaria 22; Acqua calda sanitaria 27; Acqua calda sanitaria 28

# IfcValve: Attrezzatura meccanica : Collettore acqua calda sanitaria_4 vie : Collettore acqua calda sanitaria_4 vie (2)
In: A-03-FIN
Type - Material: Brass - Nickel, BRASS - CW617N, Plastic - Red
Pset Descrizione_Entità - Descrizione_Entità: Collettore acqua calda sanitaria 4 vie
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Collettore idrico sanitario per impianto in multistrato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.02.09.01-02-03
Pset Main Dimensions - Main Dimensions: DN20
Abaco IFCGUID - Famiglia e tipo: Collettore acqua calda sanitaria_4 vie: Collettore acqua calda sanitaria_4 vie
Name (Attrezzatura meccanica : Collettore acqua calda sanitaria_4 vie :...) | Group
 Collettore acqua calda sanitaria_4 vie | Ricircolo acqua calda sanitaria 4; Acqua calda sanitaria 7; Acqua calda sanitaria 3; Acqua calda sanitaria 2; Acqua calda sanitaria 8; Acqua calda sanitaria 9
 Collettore acqua calda sanitaria_4 vie | Ricircolo acqua calda sanitaria 4; Acqua calda sanitaria 7; Acqua calda sanitaria 11; Acqua calda sanitaria 10; Acqua calda sanitaria 12; Acqua calda sanitaria 13

# IfcValve: Attrezzatura meccanica : Collettore acqua fredda sanitaria_3 vie : Collettore acqua fredda sanitaria_3 vie (5)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Brass - Nickel, BRASS - CW617N, Plastic - Blue
Pset Descrizione_Entità - Descrizione_Entità: Collettore acqua fredda sanitaria 3 vie
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Collettore idrico sanitario per impianto in multistrato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.02.09.01-02-03
Pset Main Dimensions - Main Dimensions: DN20
Abaco IFCGUID - Famiglia e tipo: Collettore acqua fredda sanitaria_3 vie: Collettore acqua fredda sanitaria_3 vie
Name (Attrezzatura meccanica : Collettore acqua fredda sanitaria_3 vie :...) | Group
 Collettore acqua fredda sanitaria_3 vie | Acqua fredda sanitaria 7; Acqua fredda sanitaria 6; Acqua fredda sanitaria 5; Acqua fredda sanitaria 4
 Collettore acqua fredda sanitaria_3 vie | Acqua fredda sanitaria 1; Acqua fredda sanitaria 16; Acqua fredda sanitaria 15; Acqua fredda sanitaria 9
 Collettore acqua fredda sanitaria_3 vie | Acqua fredda sanitaria 1; Acqua fredda sanitaria 21; Acqua fredda sanitaria 28; Acqua fredda sanitaria 29
 Collettore acqua fredda sanitaria_3 vie | Acqua fredda sanitaria 7; Acqua fredda sanitaria 36; Acqua fredda sanitaria 34; Acqua fredda sanitaria 37
 Collettore acqua fredda sanitaria_3 vie | Acqua fredda sanitaria 7; Acqua fredda sanitaria 18; Acqua fredda sanitaria 25; Acqua fredda sanitaria 30; Acqua fredda sanitaria 31

# IfcValve: Attrezzatura meccanica : Collettore acqua fredda sanitaria_4 vie : Collettore acqua fredda sanitaria_4 vie (3)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Brass - Nickel, BRASS - CW617N, Plastic - Blue
Pset Descrizione_Entità - Descrizione_Entità: Collettore acqua fredda sanitaria 4 vie
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.3.1-2
Pset Main Mechanical Data - Main Mechanical Data: Collettore idrico sanitario per impianto in multistrato
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.02.09.01-02-03
Pset Main Dimensions - Main Dimensions: DN20
Abaco IFCGUID - Famiglia e tipo: Collettore acqua fredda sanitaria_4 vie: Collettore acqua fredda sanitaria_4 vie
Name (Attrezzatura meccanica : Collettore acqua fredda sanitaria_4 vie :...) | Group
 Collettore acqua fredda sanitaria_4 vie | Acqua fredda sanitaria 7; Acqua fredda sanitaria 8; Acqua fredda sanitaria 3; Acqua fredda sanitaria 2; Acqua fredda sanitaria 10
 Collettore acqua fredda sanitaria_4 vie | Acqua fredda sanitaria 7; Acqua fredda sanitaria 13; Acqua fredda sanitaria 12; Acqua fredda sanitaria 11; Acqua fredda sanitaria 14
 Collettore acqua fredda sanitaria_4 vie | Acqua fredda sanitaria 18; Acqua fredda sanitaria 19; Acqua fredda sanitaria 33; Acqua fredda sanitaria 32; Acqua fredda sanitaria 27; Acqua fredda sanitaria 26
