Properties of the parts of a building model (IFC4), part 4 of 6

# IfcDistributionPort (3120)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_1486720_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
InPort_1486739_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
OutPort_1485924_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 32
InPort_1485945_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
OutPort_1486693_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
InPort_1486695_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
OutPort_1485945_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 33
InPort_1485993_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
OutPort_1486869_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
InPort_1487621_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
OutPort_1485993_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
InPort_1486014_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
OutPort_1487673_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
InPort_1487675_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
OutPort_1486014_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 23
InPort_1487201_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
OutPort_1489137_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
InPort_1487718_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
OutPort_1487201_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 22
InPort_1487245_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
OutPort_1489141_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
InPort_1487850_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
OutPort_1487245_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
InPort_1487295_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
OutPort_1489139_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
InPort_1487814_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
OutPort_1487295_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
InPort_1487386_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
OutPort_1487398_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
InPort_1487411_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
OutPort_1487386_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
InPort_1487401_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
OutPort_1487411_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 31
InPort_1487449_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
OutPort_1487457_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
InPort_1487472_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
OutPort_1487449_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
InPort_1487460_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
OutPort_1487472_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 30
InPort_1487617_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
OutPort_1487545_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
InPort_1487545_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
OutPort_1487621_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
InPort_1487555_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
OutPort_1487617_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 24
InPort_1487804_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
OutPort_1487814_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
InPort_1487816_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
OutPort_1487804_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 27
InPort_1487838_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
OutPort_1487850_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
InPort_1487852_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
OutPort_1487838_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 28
InPort_1488032_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1488013_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1488013_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673772_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1488030_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1488963_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1488033_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1488032_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489051_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1488033_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1673780_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1488038_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1488038_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1491974_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1488141_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1488078_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1488078_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673726_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1488088_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1488883_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1489049_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1488093_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1488093_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1488141_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1488095_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1488141_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1488100_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1492910_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673742_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1488100_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1488240_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488258_5 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1673686_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488240_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489033_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488256_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488258_4 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488259_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488259_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489063_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1492830_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488264_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488264_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1673698_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488484_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488486_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488494_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488484_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488665_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488667_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488675_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1488665_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1488883_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1489049_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1488963_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489051_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489063_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489033_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489585_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489595_3 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489601_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489585_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489595_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1489596_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1489740_3 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489738_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489738_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489750_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489741_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489740_4 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1489740_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1489979_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489791_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1489793_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1489803_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1489791_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489793_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489794_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489793_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489944_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1489834_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489836_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489846_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489834_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489836_4 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489837_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489896_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489836_5 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489893_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489895_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489905_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489893_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489895_4 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489896_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1489941_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489943_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489941_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489955_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489943_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489944_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1489978_3 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489976_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489976_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489988_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1489978_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1489979_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1490081_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1493280_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1490088_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1493282_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1490107_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1493364_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1490486_4 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1490107_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1490123_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1490339_5 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1493870_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1490123_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1490145_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1490380_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1490145_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494702_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1490170_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1490486_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1490170_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1493841_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1490339_3 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1490337_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1490337_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1490352_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1490340_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1490339_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1493280_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1490340_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1490378_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1490380_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1490378_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1490390_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1490381_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1490380_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1493282_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1490381_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1490484_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1490486_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1490484_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1490499_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1491887_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1492830_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1493065_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1491887_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1492910_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1491929_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1491929_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1493033_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1491974_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1491964_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1491964_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1492987_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1492122_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1492291_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1492144_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1492293_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1492307_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1492188_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1493364_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1493346_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1493532_3 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1493530_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1493530_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1493545_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1493533_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1493532_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1494853_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1493532_5 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672470_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1493533_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1493590_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672498_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672472_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1493590_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1493829_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1493831_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1493829_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1493843_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1493831_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1493832_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1493926_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1494580_5 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1494157_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1493926_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494569_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494698_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494569_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494702_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494578_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494580_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494578_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494698_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494580_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494581_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1672637_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1494853_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1494918_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1671240_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1502266_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1498103_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1498165_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502308_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1498194_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1502360_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1503207_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 19
OutPort_1501283_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 19
Port_1501283_5 | SOURCEANDSINK | PIPE | HEATING | Ritorno sistema idronico 1 (1)
Port_1502800_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ritorno sistema idronico 1 (1)
InPort_1501283_6 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 17
OutPort_1502758_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 17
Port_1501283_7 | SOURCEANDSINK | PIPE | HEATING | Mandata sistema idronico 1
Port_1501283_8 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_1501283_9 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_1501283_10 | SOURCEANDSINK | CABLECARRIER | CONVEYING
OutPort_1501283_12 | SOURCE | PIPE | DOMESTICHOTWATER
Port_1501283_14 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_1501283_15 | SOURCEANDSINK | CABLECARRIER | CONVEYING
OutPort_1501283_16 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 15
InPort_1502289_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1502266_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1502522_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1502289_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1502308_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502331_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502331_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502478_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1502360_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1502381_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1502381_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1502402_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1502402_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1502454_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1502454_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1502411_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1502411_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1502478_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502493_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502487_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502625_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502487_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502493_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502626_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1502539_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1502522_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1502533_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1502539_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1502629_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1502533_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1502625_3 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1502605_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1502605_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1502629_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1502625_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1502626_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1502758_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 17
Port_1502800_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 20
OutPort_1503207_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 19
InPort_1559795_0 | SINK | PIPE | USERDEFINED | Antincendio 2
OutPort_1559680_1 | SOURCE | PIPE | USERDEFINED | Antincendio 2
Port_1559795_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560392_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1559807_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560392_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1559807_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560477_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560399_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560531_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560399_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560647_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560407_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560647_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560407_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560649_3 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560477_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560679_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560493_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560531_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560493_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560642_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561272_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560642_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562207_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560649_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560724_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560649_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560650_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560650_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561270_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560679_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561270_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560724_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561272_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560899_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562207_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1560899_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565435_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
InPort_1561778_0 | SINK | PIPE | USERDEFINED | Antincendio 2
OutPort_1561762_1 | SOURCE | PIPE | USERDEFINED | Antincendio 2
Port_1561778_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561924_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561814_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565462_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561814_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565499_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561922_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561924_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1561922_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565462_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562345_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565435_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562345_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565437_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562613_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565437_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562613_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562688_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562676_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562688_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562676_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563089_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
InPort_1562836_0 | SINK | PIPE | USERDEFINED | Antincendio 2
OutPort_1562758_1 | SOURCE | PIPE | USERDEFINED | Antincendio 2
Port_1562836_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562852_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562852_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562854_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562854_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562881_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562871_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562881_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1562871_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563081_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563068_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565489_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563068_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563089_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563079_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563083_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563079_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563085_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563081_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563083_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1563085_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565490_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
InPort_1563214_0 | SINK | PIPE | USERDEFINED | Antincendio 3
OutPort_1563204_1 | SOURCE | PIPE | USERDEFINED | Antincendio 3
Port_1563214_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564917_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
InPort_1563390_0 | SINK | PIPE | USERDEFINED | Antincendio 3
OutPort_1563237_1 | SOURCE | PIPE | USERDEFINED | Antincendio 3
Port_1563258_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563289_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563258_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563289_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564179_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563364_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564621_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563364_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563378_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563370_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563378_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563370_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564923_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563390_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563519_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563450_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564635_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563450_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563530_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563460_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564610_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563460_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563461_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563460_3 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563497_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563461_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1565229_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563497_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564635_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563517_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563519_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563517_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563530_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
InPort_1563551_0 | SINK | PIPE | USERDEFINED | Antincendio 3
OutPort_1563541_1 | SOURCE | PIPE | USERDEFINED | Antincendio 3
Port_1563551_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563586_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563578_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563586_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563578_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563734_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563588_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563734_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563588_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563956_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563686_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564313_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563686_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564178_3 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563902_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563956_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1563902_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564176_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564167_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1565164_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564167_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1565227_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564176_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564271_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564178_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564517_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564178_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564179_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564271_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564313_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564517_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1565164_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564550_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564923_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564550_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564925_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564610_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564621_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564915_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564917_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564915_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1564925_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1565178_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1565227_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1565178_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1565229_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 3
Port_1565477_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565548_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565477_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565499_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565489_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565490_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565489_3 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565523_0 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565523_1 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
Port_1565548_2 | SOURCEANDSINK | PIPE | USERDEFINED | Antincendio 2
InPort_1670800_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1671322_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1671396_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1670800_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1670840_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1671353_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1671398_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1670840_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1670889_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1671385_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1671401_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1670889_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1671314_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1671316_3 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1671322_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1671314_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1671316_5 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1671317_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1671343_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1671345_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1671353_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1671343_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1671345_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1671346_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1671379_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1671381_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1671385_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1671379_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672499_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672470_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672496_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672498_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672510_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672496_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672498_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672499_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672584_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672638_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672635_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672637_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672647_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672635_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672638_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672637_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672722_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672724_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672734_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672722_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672725_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672724_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672840_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672794_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672830_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672828_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672828_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672840_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1673088_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673086_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1673086_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673098_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1673274_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673371_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673375_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673274_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673311_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673313_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673371_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673311_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673365_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673363_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673363_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673375_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673580_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673780_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1673782_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673580_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1673609_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673742_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673744_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673609_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673698_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1673636_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1673636_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1673700_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1673684_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1673686_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1673700_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1673684_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1673726_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673724_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673724_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1673744_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673772_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673770_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1673770_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1673782_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1674311_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724361_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674311_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674512_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1674346_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1674813_5 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676897_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1674346_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674488_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724224_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674488_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1677816_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674512_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674537_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674537_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674560_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674550_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674560_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674550_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1674612_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676797_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676659_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1674612_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674805_0 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1674805_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1674824_2 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1674813_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674813_4 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674814_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674814_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1677814_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1674818_0 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677796_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1674818_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1674824_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677629_0 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
InPort_1675983_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678173_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677135_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1675983_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678209_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676235_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676235_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676648_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676648_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676646_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676646_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676659_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676695_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676697_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676703_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676695_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676783_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676697_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676697_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676917_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677453_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676698_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676698_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676897_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678175_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676703_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676797_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676783_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676908_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678293_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677122_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676908_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678295_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676916_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676917_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1676916_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1676916_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677215_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677164_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678211_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677204_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678086_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677250_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677204_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678088_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677214_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677215_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677214_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677214_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677269_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677262_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678072_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677289_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677262_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678074_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677268_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677269_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677268_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677268_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677312_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677301_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678002_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677410_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677301_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678004_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677311_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677312_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677311_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677311_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677454_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677447_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677906_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677474_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677447_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677908_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677453_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677454_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677453_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677589_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1677620_0 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677620_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677642_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677628_3 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1678325_0 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677628_4 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1678384_0 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677628_5 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677629_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677636_0 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677782_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677636_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677642_2 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677784_0 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
InPort_1677680_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1677782_2 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677784_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677796_2 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677798_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677798_0 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1677814_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1677816_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1677906_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1677908_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678002_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678004_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678072_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678074_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678086_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678088_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678173_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678175_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678211_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678209_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
InPort_1678293_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
OutPort_1678295_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1678325_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1678384_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1678422_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1678422_2 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1678424_1 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
Port_1678424_2 | SOURCEANDSINK | PIPE |  | Acqua osmotizzata 1
InPort_1723145_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1723237_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1723237_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1723225_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1723225_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1723252_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1723252_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1723490_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1723502_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1723490_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1723746_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1724109_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1724030_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1724038_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1724105_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1724030_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1724040_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1724105_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1724109_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1724040_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
Port_1724224_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724393_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724345_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724361_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724345_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724373_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724365_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724373_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724365_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724397_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
Port_1724375_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | Acqua osmotizzata 1
