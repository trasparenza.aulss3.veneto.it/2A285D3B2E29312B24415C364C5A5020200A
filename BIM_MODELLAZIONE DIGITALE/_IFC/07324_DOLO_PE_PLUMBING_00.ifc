Properties of the parts of a building model (IFC4), part 2 of 6

# IfcDistributionPort (3120)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_1420478_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
InPort_1420785_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 6
OutPort_1420725_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 6
InPort_1420863_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1453308_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1480034_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1420911_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1420929_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1480034_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1450745_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1420929_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1444442_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1450717_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1453300_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1444442_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1450717_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1453422_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1450731_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1453539_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1452520_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1450745_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1450747_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1452518_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1495593_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1450747_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1452518_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1452520_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1453298_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1453300_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1453308_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1453298_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1453422_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1495556_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1453539_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1495573_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1454113_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1480623_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1454331_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1454113_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1454174_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1480676_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1454174_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1454372_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1480704_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1454220_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1454220_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1454413_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1454932_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458139_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1454933_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1457993_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1455094_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458113_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1455095_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458077_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1455170_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1455155_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
Port_1455333_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1472459_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455333_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455352_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455342_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455352_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455342_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455813_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455355_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455835_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455355_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455815_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455378_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1472461_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455378_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455400_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455391_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1472459_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455391_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1472461_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455394_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455400_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455394_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455813_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455836_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455835_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455836_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
InPort_1457499_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1472118_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
InPort_1472175_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1457499_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
InPort_1457821_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1457831_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1457831_2 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469384_0 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1457993_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458395_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458077_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458337_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458113_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458305_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458139_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458366_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458305_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458297_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458297_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458538_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458337_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458327_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458327_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458484_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458366_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458360_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458360_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458536_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458395_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458387_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458387_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458482_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458698_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458472_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458472_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672472_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458482_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458485_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458485_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458484_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458484_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458700_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1458712_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458528_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458528_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1489522_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458536_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458539_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458539_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458538_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458538_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459042_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458700_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1458698_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1489596_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1458712_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1458872_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1458735_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1458735_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489601_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1458874_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1458872_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1458926_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1458874_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1458928_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1458926_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1489479_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1458928_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459042_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1489595_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459485_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1724797_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459486_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459489_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459487_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459493_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459488_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459491_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459489_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459511_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459491_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459503_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459493_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459499_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459495_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1724831_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1724846_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459495_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459499_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459497_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459497_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459525_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459503_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459501_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459501_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459517_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1724831_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459505_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459505_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459523_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459511_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459509_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459509_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459515_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459529_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459513_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459513_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672647_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459515_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459518_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459518_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459517_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459517_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459530_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459532_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459521_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459521_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459674_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459523_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459526_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459526_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459525_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459525_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459533_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459530_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459529_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459546_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459532_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459533_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459545_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459539_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459535_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459535_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459549_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459549_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459537_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459537_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459545_3 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459540_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459539_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459542_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459540_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459543_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459542_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459709_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459543_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459545_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459546_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459662_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459664_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459674_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459662_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1459664_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494581_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1459664_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1494918_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459665_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1462836_5 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1489522_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459665_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459697_3 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459695_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459695_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459709_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1459697_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1463107_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1459697_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1493832_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462804_5 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459698_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459698_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1489479_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459752_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459799_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459757_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459752_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459802_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459754_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459754_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1672553_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459756_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459794_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459780_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 8
OutPort_1459756_6 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 8
InPort_1462564_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
OutPort_1459756_7 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
InPort_1462485_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1459756_8 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1462520_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1459756_9 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1462540_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
OutPort_1459756_10 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
InPort_1459786_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459757_6 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462683_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
OutPort_1459757_7 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
InPort_1462630_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
OutPort_1459757_8 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
InPort_1462461_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
OutPort_1459757_9 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
InPort_1462700_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
OutPort_1459757_10 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
InPort_1459774_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
OutPort_1462564_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
InPort_1462566_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
OutPort_1459774_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
InPort_1459782_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 8
OutPort_1459780_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 8
InPort_1672551_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459786_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459788_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1672551_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1672553_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459788_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459794_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459796_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459796_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1459797_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459797_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672510_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1459799_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1459800_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459800_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1462846_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1459806_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459802_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459805_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459806_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1459822_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459805_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462814_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1459822_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1460188_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
OutPort_1461593_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
InPort_1460189_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
OutPort_1461616_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
InPort_1460190_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
OutPort_1461537_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
InPort_1460191_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1461563_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1461760_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
OutPort_1460200_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
InPort_1460200_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
OutPort_1462628_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
InPort_1461722_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1460204_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1460204_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1462483_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1461697_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
OutPort_1460208_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
InPort_1460208_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
OutPort_1462608_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
InPort_1461659_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
OutPort_1460212_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
InPort_1460212_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
OutPort_1462566_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
InPort_1462483_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1460366_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1460366_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1462485_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1462628_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
OutPort_1460391_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
InPort_1460391_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
OutPort_1462630_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
InPort_1460566_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
OutPort_1461481_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
InPort_1460567_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1461507_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1460568_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
OutPort_1461407_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
InPort_1460569_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
OutPort_1460572_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
InPort_1460572_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
OutPort_1462182_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
InPort_1462294_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
OutPort_1460578_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
InPort_1460578_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
OutPort_1462698_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
InPort_1462182_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
OutPort_1460582_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
InPort_1460582_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
OutPort_1462538_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
InPort_1461800_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
OutPort_1460586_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
InPort_1460586_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
OutPort_1462449_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
InPort_1462263_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1460590_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1460590_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1462518_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1462518_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1460594_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1460594_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1462520_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1462538_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
OutPort_1460602_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
InPort_1460602_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
OutPort_1462540_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 10
InPort_1462698_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
OutPort_1460606_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
InPort_1460606_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
OutPort_1462700_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
InPort_1461407_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
OutPort_1462294_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 9
InPort_1461481_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
OutPort_1461800_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
InPort_1461507_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1462263_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1461537_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
OutPort_1461760_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 2
InPort_1461563_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
OutPort_1461722_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 2
InPort_1461593_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
OutPort_1461697_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
InPort_1461616_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
OutPort_1461659_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 3
InPort_1462445_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
OutPort_1462461_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
InPort_1462449_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
OutPort_1462445_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 8
InPort_1462603_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
OutPort_1462683_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
InPort_1462608_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
OutPort_1462603_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 3
InPort_1462804_3 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462802_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462802_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462814_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462805_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462804_4 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1493831_5 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462805_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462834_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1462836_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1462846_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1462834_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1462836_4 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1462837_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1462837_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1494157_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1462870_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1462893_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1462875_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1462870_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1462896_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462872_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462872_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462938_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462874_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1462888_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1462878_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 13
OutPort_1462874_6 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 13
InPort_1462988_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
OutPort_1462874_7 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
InPort_1462978_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462874_8 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462982_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462874_9 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462986_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
OutPort_1462874_10 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
InPort_1462882_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462875_6 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1463000_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
OutPort_1462875_7 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
InPort_1462998_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1462875_8 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1462974_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
OutPort_1462875_9 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
InPort_1463004_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
OutPort_1462875_10 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
InPort_1462876_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
OutPort_1462988_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
InPort_1462990_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
OutPort_1462876_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
InPort_1462880_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 13
OutPort_1462878_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 13
InPort_1462886_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462882_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462884_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462886_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462938_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462884_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462888_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672830_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672794_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1462890_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1462890_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1462891_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1462891_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672734_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1462893_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1462894_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1462894_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1463082_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1462898_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462896_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462897_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462898_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462900_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462897_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1463118_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1462900_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1462902_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
OutPort_1462950_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
InPort_1462903_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
OutPort_1462952_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
InPort_1462904_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1723746_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1462905_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462948_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1724020_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1462906_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1462906_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1462996_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1462958_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462908_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462908_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462976_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462956_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
OutPort_1462910_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
InPort_1462910_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
OutPort_1462994_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
InPort_1462954_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
OutPort_1462912_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
InPort_1462912_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
OutPort_1462990_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
InPort_1462976_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462914_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462914_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462978_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462996_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1462916_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1462916_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1462998_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1462918_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
OutPort_1462942_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
InPort_1462919_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1723145_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462920_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
OutPort_1462940_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
InPort_1462921_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
OutPort_1462922_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
InPort_1462922_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
OutPort_1462964_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
InPort_1462968_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
OutPort_1462924_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
InPort_1462924_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
OutPort_1463002_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
InPort_1462964_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
OutPort_1462926_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
InPort_1462926_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
OutPort_1462984_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
InPort_1462962_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
OutPort_1462928_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
InPort_1462928_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
OutPort_1462972_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
InPort_1723502_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462930_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462930_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462980_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462980_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462932_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462932_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462982_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462984_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
OutPort_1462934_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
InPort_1462934_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
OutPort_1462986_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 14
InPort_1463002_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
OutPort_1462936_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
InPort_1462936_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
OutPort_1463004_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
InPort_1462940_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
OutPort_1462968_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 13
InPort_1462942_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
OutPort_1462962_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
InPort_1462946_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1724020_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1724038_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
OutPort_1462946_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 10
InPort_1462948_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
OutPort_1462958_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 11
InPort_1462950_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
OutPort_1462956_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
InPort_1462952_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
OutPort_1462954_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 12
InPort_1462970_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
OutPort_1462974_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
InPort_1462972_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
OutPort_1462970_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 12
InPort_1462992_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
OutPort_1463000_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
InPort_1462994_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
OutPort_1462992_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 11
InPort_1671381_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1463050_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1463050_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672584_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1463070_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1463072_3 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1463082_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1463070_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1463072_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1671346_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1463072_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473016_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1463073_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1671345_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1463073_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1671240_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1463106_3 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1463104_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1463104_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1463118_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1463106_4 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473054_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1671317_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1463106_5 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1463107_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1671316_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1463269_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1463269_2 | SINK | PIPE | DOMESTICHOTWATER
InPort_1468854_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1463269_3 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1463270_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1463270_2 | SINK | PIPE | DOMESTICHOTWATER
InPort_1469260_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1463270_3 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1471958_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1465768_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
InPort_1468892_2 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1465861_0 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1465861_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1468896_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1465879_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1468892_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1465896_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1465879_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1468924_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1465896_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1468807_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 24
InPort_1468896_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1468854_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1468949_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1468924_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1468933_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1468949_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1469006_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1468933_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1468952_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1469006_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1469004_2 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1468952_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1469281_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469260_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1469275_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469281_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1469294_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469275_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1469286_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469294_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1469303_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469286_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1469297_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469303_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1469381_2 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469297_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1469373_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469381_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1469394_2 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469373_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1469384_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1469394_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
InPort_1472012_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1471958_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
InPort_1471971_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1472012_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
InPort_1472118_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1471971_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
InPort_1472131_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1472175_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
InPort_1472364_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1472131_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
InPort_1472178_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1472364_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
InPort_1472360_3 | SINK | PIPE | SEWAGE | Scarichi acque nere 42
OutPort_1472178_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 42
Port_1472306_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 40
Port_1472360_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 40
Port_1472306_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 40
Port_1472360_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 40
Port_1472361_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 40
Port_1472361_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 40
Port_1472625_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1472672_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
InPort_1472708_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1472718_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1472709_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1472712_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1472712_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1472995_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1472718_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1472976_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1472976_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1472728_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1472728_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1472886_4 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1472870_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1472866_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1472866_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473103_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1472868_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1472873_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1472868_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473025_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1472871_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1472870_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1472995_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1472871_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1472873_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1472887_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1472876_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1472880_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1472961_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1472876_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1472886_3 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1472878_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1472878_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1472961_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1472880_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1472881_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1472881_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1472883_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1472883_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1472881_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1472884_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1472883_2 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473065_2 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1472884_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1472886_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1472887_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473013_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473015_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473013_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473025_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473015_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1473016_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473053_3 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473051_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473051_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473065_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473054_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1473053_5 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1473091_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473093_3 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473103_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473091_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473093_4 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1672725_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473434_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473093_5 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1672724_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473094_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473094_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1671381_4 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473126_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473130_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473127_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473128_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473128_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1473160_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473130_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473158_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1473158_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473132_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
