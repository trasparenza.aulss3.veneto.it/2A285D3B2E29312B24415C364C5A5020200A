Properties of the parts of a building model (IFC4), part 1 of 6

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 3e715650-1360-4b1d-a40e-4e2c3fd44a4d, NumberOfSaves: 118], CoordinateReference [CoordinateBase: Coordinate condivise, ProjectSite: Planimetria di default]
File name: 0001
Time: 2025-03-06T18:07:23+01:00
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.11.26 (ITA) - IFC 24.1.11.26

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 45, 25, 19, 889831; RefLongitude: 12, 4, 4, 325637; RefElevation: 0 mm

# IfcBuildingStorey: Livello:Estremità 8 mm (6)
Name | LongName | Elevation (mm)
A-TR-FIN | A-TR-FIN | 0
A-01-FIN | A-01-FIN | 3690
A-02-FIN | A-02-FIN | 7380
A-03-FIN | A-03-FIN | 11910
A-04-FIN | A-04-FIN | 16610
A-CP-FIN | A-CP-FIN | 20980

# IfcDistributionPort (3120)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
Port_1326017_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 1
Port_1326463_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 1
Port_1326017_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 1
Port_1326156_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 1
Port_1326463_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 1
Port_1326156_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 1
Port_1326463_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 1
Port_1326472_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 1
Port_1326472_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 1
Port_1326537_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 2
Port_1326541_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 2
Port_1326537_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 2
Port_1326541_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 2
Port_1326543_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 2
Port_1326541_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1338996_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1326543_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 2
Port_1326567_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 3
Port_1326571_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 3
Port_1326567_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 3
Port_1326569_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 6
Port_1326571_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 6
Port_1326569_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 6
Port_1326571_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 3
Port_1326573_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 3
Port_1326573_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 3
Port_1326591_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 5
Port_1326595_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 5
Port_1326591_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 5
InPort_1326595_3 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1326593_0 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
InPort_1326593_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 8
OutPort_1469004_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 8
Port_1326595_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 5
Port_1326597_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 5
Port_1326597_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 5
Port_1326636_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 7
Port_1326640_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 7
Port_1326636_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 7
Port_1326640_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 7
Port_1326642_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 7
InPort_1326640_3 | SINK | PIPE | SEWAGE | Scarichi acque nere 10
OutPort_1457821_0 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 10
Port_1326642_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 7
Port_1326668_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 9
Port_1326672_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 9
Port_1326668_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 9
Port_1326670_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 12
Port_1326672_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 12
Port_1326670_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 12
Port_1326672_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 9
Port_1326674_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 9
Port_1326674_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 9
Port_1326699_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 11
Port_1326703_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 11
Port_1326699_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 11
Port_1326703_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 11
Port_1326705_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 11
Port_1326703_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1348953_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1326705_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 11
Port_1326747_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 13
Port_1326751_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 13
Port_1326747_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 13
Port_1326749_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 17
Port_1326751_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 17
Port_1326749_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 17
Port_1326751_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 13
Port_1326794_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 15
Port_1326798_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 15
Port_1326794_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 15
Port_1326796_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 19
Port_1326798_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 19
Port_1326796_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 19
Port_1326798_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 15
Port_1326823_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 16
Port_1326827_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 16
Port_1326823_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 16
Port_1326825_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 21
Port_1326827_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 21
Port_1326825_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 21
Port_1326827_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 16
Port_1326845_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 18
Port_1326849_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 18
Port_1326845_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 18
Port_1326847_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 23
Port_1326849_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 23
Port_1326847_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 23
Port_1326849_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 18
Port_1326869_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 20
Port_1326873_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 20
Port_1326869_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 20
Port_1326873_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 20
Port_1326873_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351872_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1326909_0 | SOURCEANDSINK | PIPE | SEWAGE | Ventilazione scarichi acque nere 1
Port_1326909_1 | SOURCEANDSINK | PIPE | SEWAGE | Ventilazione scarichi acque nere 1
Port_1326922_0 | SOURCEANDSINK | PIPE | SEWAGE | Ventilazione scarichi acque nere 2
Port_1326922_1 | SOURCEANDSINK | PIPE | SEWAGE | Ventilazione scarichi acque nere 2
Port_1327092_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 22
Port_1327096_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 22
Port_1327092_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 22
Port_1327094_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351475_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1327094_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351266_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1327096_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 22
Port_1327098_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 22
Port_1327096_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349939_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1327098_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 22
InPort_1330513_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1330513_2 | SINK | PIPE | DOMESTICHOTWATER
InPort_1468807_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 24
OutPort_1330513_3 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 24
InPort_1341282_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1331448_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1342418_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1331449_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1342522_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 30
OutPort_1331450_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 30
InPort_1342554_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 31
OutPort_1331451_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 31
Port_1335083_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1345029_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1335084_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346685_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1335085_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1346706_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1335086_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 39
Port_1347478_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 39
Port_1335087_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 36
Port_1347446_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 36
InPort_1336084_1 | SINK | PIPE | USERDEFINED
InPort_1336084_2 | SINK | PIPE | USERDEFINED
InPort_1336085_1 | SINK | PIPE | USERDEFINED
InPort_1336085_2 | SINK | PIPE | USERDEFINED
Port_1336956_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351566_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
InPort_1336957_1 | SINK | PIPE | USERDEFINED
InPort_1336957_2 | SINK | PIPE | USERDEFINED
InPort_1336958_1 | SINK | PIPE | USERDEFINED
InPort_1336958_2 | SINK | PIPE | USERDEFINED
Port_1336959_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351554_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
InPort_1336960_1 | SINK | PIPE | USERDEFINED
InPort_1336960_2 | SINK | PIPE | USERDEFINED
InPort_1336961_1 | SINK | PIPE | USERDEFINED
InPort_1336961_2 | SINK | PIPE | USERDEFINED
Port_1336962_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349630_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
InPort_1336963_1 | SINK | PIPE | USERDEFINED
InPort_1336963_2 | SINK | PIPE | USERDEFINED
InPort_1336964_1 | SINK | PIPE | USERDEFINED
InPort_1336964_2 | SINK | PIPE | USERDEFINED
Port_1336965_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349776_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1336966_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351031_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
InPort_1336967_1 | SINK | PIPE | USERDEFINED
InPort_1336967_2 | SINK | PIPE | USERDEFINED
InPort_1336968_1 | SINK | PIPE | USERDEFINED
InPort_1336968_2 | SINK | PIPE | USERDEFINED
Port_1336969_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1348819_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
InPort_1336970_1 | SINK | PIPE | USERDEFINED
InPort_1336970_2 | SINK | PIPE | USERDEFINED
InPort_1336971_1 | SINK | PIPE | USERDEFINED
InPort_1336971_2 | SINK | PIPE | USERDEFINED
Port_1337064_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337072_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337064_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337106_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337072_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337097_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337106_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337097_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337120_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337112_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337120_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337112_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337129_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337123_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337129_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337123_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338134_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1337321_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_1337391_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 27
Port_1337395_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 27
Port_1337391_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 27
Port_1337395_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 27
Port_1337397_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 27
Port_1337395_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1338353_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1337397_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 27
Port_1337550_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1338831_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1337550_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1338352_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1337582_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1338831_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1337582_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1337620_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1337614_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1337620_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1337614_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1338116_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338134_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338116_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338143_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338137_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338143_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338137_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338907_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338146_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338907_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338146_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338352_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 24
Port_1338352_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1338353_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 29
Port_1338976_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347587_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1338976_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1338987_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347816_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1338987_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347749_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1338996_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1342722_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1339309_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
Port_1342819_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
Port_1339309_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
Port_1347920_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1339354_3 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1339341_0 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1339341_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1342484_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1339354_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1339355_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1342782_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1339354_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1339355_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1455170_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1339405_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1339397_0 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1339397_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1339414_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1455155_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1339405_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1339414_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1339408_0 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1339408_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1341294_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1341294_2 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1341282_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1342186_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1342480_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1342484_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1342186_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1342480_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1342418_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1343112_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 30
OutPort_1342522_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 30
InPort_1343146_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 31
OutPort_1342554_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 31
Port_1342671_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347752_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1342671_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1342722_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
InPort_1342768_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 30
OutPort_1457613_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 30
InPort_1342781_3 | SINK | PIPE | SEWAGE | Scarichi acque nere 30
OutPort_1342768_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 30
InPort_1342781_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 28
OutPort_1342782_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 28
Port_1342781_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
Port_1342820_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1457613_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 30
OutPort_1342788_0 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 30
InPort_1342788_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 30
OutPort_1343112_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 30
InPort_1342811_0 | SINK | PIPE | SEWAGE | Scarichi acque nere 31
OutPort_1627893_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 31
InPort_1342819_3 | SINK | PIPE | SEWAGE | Scarichi acque nere 31
OutPort_1342811_1 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 31
Port_1342819_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
Port_1342820_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
InPort_1627893_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 31
OutPort_1342825_0 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 31
InPort_1342825_1 | SINK | PIPE | SEWAGE | Scarichi acque nere 31
OutPort_1343146_2 | SOURCE | PIPE | SEWAGE | Scarichi acque nere 31
Port_1343229_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343249_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343229_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343240_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343249_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343240_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343262_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343262_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343627_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343363_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343367_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343363_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343365_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343367_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343365_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343371_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343371_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343584_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343385_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343389_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343385_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343387_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343389_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343387_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343393_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343391_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343393_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343391_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343499_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343409_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343413_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343409_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343411_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343413_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343411_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343417_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343417_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343442_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343442_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343457_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343451_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343457_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343451_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343672_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343493_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343499_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343493_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343772_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343584_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343601_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343601_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343606_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343606_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343846_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343627_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343642_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343636_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343642_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343636_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343880_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343664_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343672_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343664_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343681_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343675_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343876_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343675_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343695_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343681_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343766_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343684_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343695_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343684_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343707_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343698_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347056_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343698_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343718_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343707_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347239_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343710_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343718_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343710_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347747_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343755_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343769_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343755_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343772_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343765_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343766_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343765_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343843_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343765_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343769_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 34
Port_1343830_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343842_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343830_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343846_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 33
Port_1343842_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343843_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343842_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343877_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343866_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343876_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343866_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343880_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 32
Port_1343876_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343877_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1343939_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
Port_1347920_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
Port_1343939_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
Port_1347816_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 28
Port_1345029_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346439_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346267_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346477_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346267_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346268_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346267_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346364_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346268_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347426_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346364_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346437_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346379_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346437_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346379_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346439_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346476_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347558_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346476_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346477_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346476_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346579_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346499_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347588_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346499_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346500_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346499_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1346609_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1346500_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347557_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1346579_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346599_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346593_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346599_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346593_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346693_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346609_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1347344_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1346647_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1347344_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1346647_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1347346_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1346685_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346693_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1346706_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1347346_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 38
Port_1346752_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346756_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346752_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346754_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346756_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346754_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346758_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346758_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346788_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346760_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346764_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346760_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346762_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346764_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346762_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346768_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346766_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346768_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346766_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346786_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346770_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346774_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346770_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346772_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346774_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346772_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346776_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346776_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346778_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346778_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346782_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346780_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346782_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346780_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346802_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346784_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346786_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346784_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346828_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346788_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346790_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346790_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346792_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346792_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346836_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346800_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346802_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346800_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346806_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346804_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1347060_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346804_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346832_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346806_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346823_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346808_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1347060_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346808_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1347056_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346820_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346826_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346820_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346828_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346822_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346823_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346822_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346833_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346822_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346826_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 43
Port_1346830_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346832_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346830_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346836_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 44
Port_1346832_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1346833_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 41
Port_1347056_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347057_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347057_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347422_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347182_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347426_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347182_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347422_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347239_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347268_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347268_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347423_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347422_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347423_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347446_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 36
Port_1347597_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 36
Port_1347478_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 39
Port_1347567_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 39
Port_1347555_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 39
Port_1347557_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 39
Port_1347555_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 39
Port_1347567_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 39
Port_1347557_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347558_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347585_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 36
Port_1347587_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 36
Port_1347585_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 36
Port_1347597_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 36
Port_1347587_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347588_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 37
Port_1347747_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347749_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347752_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347817_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347816_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1347817_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 4
Port_1348819_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349065_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1348904_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1348963_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1348904_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349351_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1348953_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1348963_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349052_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349065_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349052_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349078_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349070_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349078_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349070_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349199_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349136_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349199_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349136_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349351_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 14
Port_1349630_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349675_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349662_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349675_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349662_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349688_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349680_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349688_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349680_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1350962_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349691_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1350962_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349691_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1350958_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 35
Port_1349776_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349814_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349778_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349814_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349778_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349784_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349782_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349784_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349782_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349788_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349786_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349788_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349786_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349837_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349837_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1350959_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349939_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349949_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1349949_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351476_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1350958_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1350959_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1350958_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351525_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351031_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351056_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351050_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351056_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351050_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351069_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351061_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351069_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351061_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351078_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351072_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351078_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351072_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351234_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351224_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351234_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351224_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351266_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351475_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351476_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351475_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351516_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351516_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351535_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351525_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351535_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 26
Port_1351554_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1352050_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351556_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1352050_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351556_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351562_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351560_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351562_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351560_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353811_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351566_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351779_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351568_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351779_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351568_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351572_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351570_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351572_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351570_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353873_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1351872_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1472551_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1352085_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353989_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1352085_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353991_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1352998_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1472625_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1352998_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1352999_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1352998_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353053_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1352999_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1472551_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353053_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353989_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353180_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1472672_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353180_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455815_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353191_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353811_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353191_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455839_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353426_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353873_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353426_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353958_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353816_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455839_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353816_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1455835_3 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353950_0 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353958_2 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353950_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
Port_1353991_1 | SOURCEANDSINK | PIPE | SEWAGE | Scarichi acque nere 25
InPort_1354088_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1454331_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1498103_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1354088_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1454413_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1354117_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1354117_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1498194_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
Port_1354130_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1454372_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1354130_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1498165_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1354563_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1450731_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1453262_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1354563_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1354864_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1489978_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1354864_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1490499_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
Port_1354889_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1489943_5 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1354889_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
Port_1490390_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1354916_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1489895_5 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1490352_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1354916_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1473053_4 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1354988_0 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1354988_1 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1673211_1 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1355047_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1473015_5 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1673313_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1355047_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1382182_5 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
OutPort_1420863_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 7
InPort_1420725_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 6
OutPort_1382182_6 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 6
InPort_1420180_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
OutPort_1382182_7 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
InPort_1420126_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1382182_8 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1420104_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1382182_9 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1382206_5 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1383244_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1420911_0 | SINK | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
OutPort_1382206_6 | SOURCE | PIPE | DOMESTICHOTWATER | Ricircolo acqua calda sanitaria 4
InPort_1420490_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
OutPort_1382206_7 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
InPort_1419606_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
OutPort_1382206_8 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
InPort_1383244_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
OutPort_1453262_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 7
InPort_1414803_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
OutPort_1419321_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
InPort_1414890_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419290_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419290_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419721_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419321_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
OutPort_1419491_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
InPort_1419491_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
OutPort_1419543_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
InPort_1419543_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
OutPort_1419562_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
InPort_1419562_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
OutPort_1419554_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
InPort_1419554_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
OutPort_1419604_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
InPort_1419604_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
OutPort_1419565_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
InPort_1419565_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
OutPort_1419606_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 4
InPort_1419721_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419707_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419707_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419766_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419766_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419758_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419758_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1420102_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1420102_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419769_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419769_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1420104_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1420124_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419792_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419792_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1420126_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419805_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1420124_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419893_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419805_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419847_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
OutPort_1419930_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
InPort_1419848_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419885_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419885_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
OutPort_1419893_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 4
InPort_1419932_2 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
OutPort_1419918_0 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
InPort_1419918_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
OutPort_1420492_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
InPort_1419930_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
OutPort_1419932_1 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
InPort_1420184_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
OutPort_1420180_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
InPort_1420448_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
OutPort_1420184_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
InPort_1420208_0 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
OutPort_1420448_2 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
InPort_1420450_2 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
OutPort_1420208_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
InPort_1420413_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
OutPort_1420442_0 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
InPort_1420442_1 | SINK | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
OutPort_1420450_1 | SOURCE | PIPE | DOMESTICCOLDWATER | Acqua fredda sanitaria 5
InPort_1420478_0 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
OutPort_1420490_2 | SOURCE | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
InPort_1420492_1 | SINK | PIPE | DOMESTICHOTWATER | Acqua calda sanitaria 5
