Properties of the parts of a building model (IFC4), part 17 of 17

# IfcUnitaryEquipment: Attrezzatura meccanica : RSen_55_ME_FB_SOg - fxaq32auv1b - SH_daikin_tbq : standard
Type - PredefinedType: SPLITSYSTEM; Material: RSen_x_rgb 055 053 053 T00 gray_gen, RSen_x_rgb 244 244 244 T00 signal white_gen, RSen_x_rgb 0 0 0 T30 aluminium rectangular canvas_gen
Pset Descrizione_Entità - Descrizione_Entità: Unità interna condizionatore
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Unità interna per sistema split a espansione diretta
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 035131b-c
Abaco IFCGUID - Famiglia e tipo: RSen_55_ME_FB_SOg - fxaq32auv1b - SH_daikin_tbq: standard; WBS_01: DBE; WBS_02: IM; WBS_03: P03

# IfcUnitaryEquipment: Attrezzatura meccanica : RSen_55_ME_FB_SOg - fxaq40auv1b - SH_daikin_tbq : standard
In: A-03-FIN
Type - PredefinedType: SPLITSYSTEM; Material: RSen_x_rgb 055 053 053 T00 gray_gen, RSen_x_rgb 244 244 244 T00 signal white_gen, RSen_x_rgb 0 0 0 T30 aluminium rectangular canvas_gen
Pset Descrizione_Entità - Descrizione_Entità: Unità interna condizionatore
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Unità interna per sistema split a espansione diretta
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 035131c
Abaco IFCGUID - Famiglia e tipo: RSen_55_ME_FB_SOg - fxaq40auv1b - SH_daikin_tbq: standard; WBS_01: DBE; WBS_02: IM; WBS_03: P03

# IfcUnitaryEquipment: Attrezzatura meccanica : RSen_55_ME_FB_SOg - fxzq25a2veb - fully flat decoration panel - SH_daikin_tbq : standard (2)
In: A-03-FIN
Type - PredefinedType: SPLITSYSTEM; Material: RSen_x_rgb 055 053 053 T00 gray_gen, RSen_x_rgb 199 235 223 T00 galvanised steel plate_gen (2), RSen_x_rgb 244 244 244 T00 signal white_gen, RSen_x_rgb 40 40 40 T00 canvas_gen
Material: RSen_x_rgb 055 053 053 T00 gray_gen, RSen_x_rgb 199 235 223 T00 galvanised steel plate_gen, RSen_x_rgb 244 244 244 T00 signal white_gen, RSen_x_rgb 40 40 40 T00 canvas_gen
Pset Descrizione_Entità - Descrizione_Entità: Unità interna condizionatore su controsoffitto
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Unità interna a 4 vie per sistema ad espansione diretta
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 035131b
Abaco IFCGUID - Famiglia e tipo: RSen_55_ME_FB_SOg - fxzq25a2veb - fully flat decoration panel - SH_daikin_tbq: standard; WBS_01: DBE; WBS_02: IM; WBS_03: P03

# IfcUnitaryEquipment: Attrezzatura meccanica : RSen_55_ME_FB_SOg - rxysq5t8yb9 - SH_daikin_tbq : standard (2)
In: A-04-FIN
Type - PredefinedType: SPLITSYSTEM; Material: RSen_x_rgb 000 163 228 T00 blue_gen, RSen_x_rgb 079 201 245 T00 blue_gen, RSen_x_rgb 055 053 053 T00 gray_gen, RSen_x_rgb 202 196 176 T00 silk gray_gen, RSen_x_rgb 079 201 245 T00 blue rectangular canvas_gen, RSen_x_rgb 0 0 0 T30 aluminium rectangular canvas_gen
Pset Descrizione_Entità - Descrizione_Entità: Unità esterna condizionatore
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: PC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Unità esterna per sistema ad espansione diretta
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Abaco IFCGUID - Famiglia e tipo: RSen_55_ME_FB_SOg - rxysq5t8yb9 - SH_daikin_tbq: standard; WBS_01: DBE; WBS_02: IM; WBS_03: PC
Name (Attrezzatura meccanica : RSen_55_ME_FB_SOg - rxysq5t8yb9 - SH_daikin_tbq :...) | RIF_EPU
 standard | VEN24-12.02.59.05
 standard | 035124d

# IfcUnitaryEquipment: Attrezzatura meccanica : Split a parete : taglia 25
In: A-03-FIN
Type - PredefinedType: SPLITSYSTEM; Material: RSen_x_rgb 255 255 255 T00 pure white_gen
Pset Descrizione_Entità - Descrizione_Entità: Cassetta vrv a parete
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Unità interna per sistema split a espansione diretta
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 035136a
Abaco IFCGUID - Famiglia e tipo: Split a parete: taglia 25; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: REF 6; REF 7

# IfcUnitaryEquipment: Attrezzatura meccanica : Split a parete : taglia 32
In: A-03-FIN
Type - PredefinedType: SPLITSYSTEM; Material: RSen_x_rgb 255 255 255 T00 pure white_gen
Pset Descrizione_Entità - Descrizione_Entità: Cassetta vrv a parete
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Unità interna per sistema split a espansione diretta
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 035131c
Abaco IFCGUID - Famiglia e tipo: Split a parete: taglia 32; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: SR 3; SR 4

# IfcUnitaryEquipment: Attrezzatura meccanica : UTA : UTA (3)
In: A-04-FIN
Type - PredefinedType: AIRHANDLER; Material: Default
Pset Descrizione_Entità - Descrizione_Entità: Unità trattamento aria
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: PC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.3
Pset RIF_Crono - RIF_Crono: M3_S7_G20
Pset RIF_EPU - RIF_EPU: M21.ndt.101-106
Abaco IFCGUID - Famiglia e tipo: UTA: UTA; WBS_01: DBE; WBS_02: IM; WBS_03: PC
Name (Attrezzatura meccanica : UTA :...) | Main Mechanical Data | Group
 UTA | Portata=7260m³/H prevalenza 500Pa | Meccanico Aria di ritorno 1; Meccanico Aria di mandata 2; Meccanico Aria di scarico 9; Meccanico Aria esterna 9
 UTA | Portata=5720m³/H prevalenza 700Pa | Meccanico Aria di mandata 7; Meccanico Aria di ritorno 6; Meccanico Aria di scarico 11; Meccanico Aria esterna 8
 UTA | Portata=10740m³/h prevalenza 700Pa | Meccanico Aria di ritorno 1; Meccanico Aria di mandata 2; Meccanico Aria di scarico 4; Meccanico Aria di mandata 1; Meccanico Aria esterna 7

# IfcUnitaryEquipment: Attrezzatura meccanica : UTA_3_sezioni : UTA 3 sezioni (6)
In: A-04-FIN
Type - PredefinedType: AIRHANDLER; Material: Default
Pset Descrizione_Entità - Descrizione_Entità: UTA Sala Operatoria
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: PC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.3
Pset RIF_Crono - RIF_Crono: M3_S7_G20
Pset RIF_EPU - RIF_EPU: M21.ndt.101-106
Abaco IFCGUID - Famiglia e tipo: UTA_3_sezioni: UTA 3 sezioni; WBS_01: DBE; WBS_02: IM; WBS_03: PC
Name (Attrezzatura meccanica : UTA_3_sezioni :...) | Main Mechanical Data | Group
 UTA 3 sezioni | Portata=7169m³/H prevalenza 700Pa | Meccanico Aria di mandata 25; Meccanico Aria di ritorno 9; Meccanico Aria esterna 1; Meccanico Aria di scarico 1
 UTA 3 sezioni | Portata=3230m³/H prevalenza 700Pa | Meccanico Aria di mandata 32 (1); Meccanico Aria di ritorno 19 (1); Meccanico Aria esterna 2
 UTA 3 sezioni | Portata=4660m³/H prevalenza 700Pa | Meccanico Aria di mandata 19 (1); Meccanico Aria di ritorno 22; Meccanico Aria esterna 6; Meccanico Aria di scarico 7
 UTA 3 sezioni | Portata=7380m³/H prevalenza 700Pa | Meccanico Aria di mandata 8; Meccanico Aria di ritorno 14; Meccanico Aria esterna 3; Meccanico Aria di scarico 2
 UTA 3 sezioni | Portata=7500m³/H prevalenza 700Pa | Meccanico Aria di mandata 11; Meccanico Aria di ritorno 15; Meccanico Aria esterna 4; Meccanico Aria di scarico 3
 UTA 3 sezioni | Portata=3150m³/H prevalenza 700Pa | Meccanico Aria di mandata 34; Meccanico Aria di ritorno 17; Meccanico Aria esterna 5; Meccanico Aria di scarico 5

# IfcValve: Accessori per tubazioni : Detentore DN15 : 1/2''_1.8 m³/h (18)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Metal - Caleffi - Brass
Pset Descrizione_Entità - Descrizione_Entità: Detentore DN15
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Detentore in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.32.02-04
Pset Main Dimensions - Main Dimensions: DN15
Abaco IFCGUID - Famiglia e tipo: Detentore DN15: 1/2''_1.8 m³/h; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Mandata Post 2 (1) (1)

# IfcValve: Accessori per tubazioni : Detentore DN20 : 3/4''_0.2 m³/h (8)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Metal - Caleffi - Brass
Pset Descrizione_Entità - Descrizione_Entità: Detentore DN20
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Detentore in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.32.02-04
Pset Main Dimensions - Main Dimensions: DN20
Abaco IFCGUID - Famiglia e tipo: Detentore DN20: 3/4''_0.2 m³/h; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Mandata Post 2 (1) (1)

# IfcValve: Accessori per tubazioni : Detentore DN25 : 1''_2.0 m³/h
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Metal - Caleffi - Brass
Pset Descrizione_Entità - Descrizione_Entità: Detentore DN25
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Detentore in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.32.02-04
Pset Main Dimensions - Main Dimensions: DN25
Abaco IFCGUID - Famiglia e tipo: Detentore DN25: 1''_2.0 m³/h; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Mandata Post 2 (1) (1)

# IfcValve: Accessori per tubazioni : Detentore DN32 : 1 1/4''_2.0 m³/h
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Metal - Caleffi - Brass
Pset Descrizione_Entità - Descrizione_Entità: Detentore DN32
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Detentore in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.32.02-04
Pset Main Dimensions - Main Dimensions: DN32
Abaco IFCGUID - Famiglia e tipo: Detentore DN32: 1 1/4''_2.0 m³/h; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Mandata Post 2 (1) (1)

# IfcValve: Accessori per tubazioni : Valvola a farfalla flangiata : DN100 (4)
In: A-I1-FIN
Type - PredefinedType: USERDEFINED; Material: Lever_L9, Area, Blu_L9, Black_L9
Pset Descrizione_Entità - Descrizione_Entità: Valvola a farfalla
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a farfalla in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.50.05-10
Abaco IFCGUID - Famiglia e tipo: Valvola a farfalla flangiata: DN100; WBS_01: DBE; WBS_02: IM; WBS_03: I00
Group: RIS 10

# IfcValve: Accessori per tubazioni : Valvola a farfalla flangiata : DN150 (4)
In: A-I1-FIN
Type - PredefinedType: USERDEFINED; Material: Lever_L9, Area, Blu_L9, Black_L9
Pset Descrizione_Entità - Descrizione_Entità: Valvola a farfalla
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a farfalla in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.50.05-10
Abaco IFCGUID - Famiglia e tipo: Valvola a farfalla flangiata: DN150; WBS_01: DBE; WBS_02: IM; WBS_03: I00
Name (Accessori per tubazioni : Valvola a farfalla flangiata :...) | Group
2 x  DN150 | REF 9
2 x  DN150 | REF 2

# IfcValve: Accessori per tubazioni : Valvola a sfera con leva : DN15 (46)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Leva black, <Unnamed>, Ottone, Ottone(M)
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a sfera in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.35.01-06
Abaco IFCGUID - Famiglia e tipo: Valvola a sfera con leva: DN15; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per tubazioni : Valvola a sfera con leva :...) | Group
23 x  DN15 | Ritorno Post 1 (1) (1)
23 x  DN15 | Mandata Post 2 (1) (1)

# IfcValve: Accessori per tubazioni : Valvola a sfera con leva : DN20 (16)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Leva black, <Unnamed>, Ottone, Ottone(M)
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a sfera in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.35.01-06
Abaco IFCGUID - Famiglia e tipo: Valvola a sfera con leva: DN20; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per tubazioni : Valvola a sfera con leva :...) | Group
8 x  DN20 | Ritorno Post 1 (1) (1)
8 x  DN20 | Mandata Post 2 (1) (1)

# IfcValve: Accessori per tubazioni : Valvola a sfera con leva : DN25 (2)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Leva black, <Unnamed>, Ottone, Ottone(M)
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a sfera in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.35.01-06
Abaco IFCGUID - Famiglia e tipo: Valvola a sfera con leva: DN25; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per tubazioni : Valvola a sfera con leva :...) | Group
 DN25 | Ritorno Post 1 (1) (1)
 DN25 | Mandata Post 2 (1) (1)

# IfcValve: Accessori per tubazioni : Valvola a sfera con leva : DN32 (2)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: Leva black, <Unnamed>, Ottone, Ottone(M)
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a sfera in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.35.01-06
Abaco IFCGUID - Famiglia e tipo: Valvola a sfera con leva: DN32; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per tubazioni : Valvola a sfera con leva :...) | Group
 DN32 | Ritorno Post 1 (1) (1)
 DN32 | Mandata Post 2 (1) (1)

# IfcValve: Accessori per tubazioni : Valvola a sfera con leva : DN50 (4)
In: A-I1-FIN
Type - PredefinedType: USERDEFINED; Material: Leva black, <Unnamed>, Ottone, Ottone(M)
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a sfera in bronzo
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.35.01-06
Abaco IFCGUID - Famiglia e tipo: Valvola a sfera con leva: DN50; WBS_01: DBE; WBS_02: IM; WBS_03: I00
Group: Mandata Post 2 (1) (1)

# IfcValve: Accessori per tubazioni : Valvola motorizzata a 3 vie : DN20 (26)
In: A-03-FIN
Type - PredefinedType: REGULATING; Material: Tiemme logo, Tiemme_BRASS-CW617N_Nickel, Tiemme_PA_BLACK
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera motorizzata a 3 vie maschio/maschio con servocomando.
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a 3 vie con servocomando
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.27.01-03
Abaco IFCGUID - Famiglia e tipo: Valvola motorizzata a 3 vie: DN20; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Ritorno Post 1 (1) (1)

# IfcValve: Accessori per tubazioni : Valvola motorizzata a 3 vie : DN25
In: A-03-FIN
Type - PredefinedType: REGULATING; Material: Tiemme logo, Tiemme_BRASS-CW617N_Nickel, Tiemme_PA_BLACK
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera motorizzata a 3 vie maschio/maschio con servocomando.
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a 3 vie con servocomando
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.27.01-03
Abaco IFCGUID - Famiglia e tipo: Valvola motorizzata a 3 vie: DN25; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Ritorno Post 1 (1) (1)

# IfcValve: Accessori per tubazioni : Valvola motorizzata a 3 vie : DN32
In: A-03-FIN
Type - PredefinedType: REGULATING; Material: Tiemme logo, Tiemme_BRASS-CW617N_Nickel, Tiemme_PA_BLACK
Pset Descrizione_Entità - Descrizione_Entità: Valvola a sfera motorizzata a 3 vie maschio/maschio con servocomando.
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola a 3 vie con servocomando
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.27.01-03
Abaco IFCGUID - Famiglia e tipo: Valvola motorizzata a 3 vie: DN32; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Ritorno Post 1 (1) (1)
