Properties of the parts of a building model (IFC4), part 7 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_1374483_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374498_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374474_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1426647_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374558_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374558_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1377153_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1426522_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1374589_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1374589_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1377176_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1374613_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374622_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1851132_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374613_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374622_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1426649_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374697_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1446453_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1453771_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1374697_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376072_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376070_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376070_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376071_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376070_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376079_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376070_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376080_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376073_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376072_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1380555_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376073_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376078_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376075_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376077_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376076_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376079_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376077_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376080_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376078_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403949_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376081_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376081_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403912_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376084_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376082_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376082_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376083_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376082_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376090_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376082_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376091_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376085_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376084_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403912_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376085_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376089_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376086_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376088_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376087_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376090_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376088_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376091_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376089_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376092_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403898_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403913_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376092_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1380670_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376093_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376093_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1380679_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376096_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376094_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376094_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376095_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376094_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376103_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376094_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376104_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376097_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376096_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1380679_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376097_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376102_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376099_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376101_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376100_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376103_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376101_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376104_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376102_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376108_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376106_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376106_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376107_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376106_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376115_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376106_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376116_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376109_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376108_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403830_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376109_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376114_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376111_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376113_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376112_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376115_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376113_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376116_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376114_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376120_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1380680_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1380331_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376120_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376120_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1404201_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376127_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403721_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403685_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376127_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376129_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1380981_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1380680_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1376129_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1376178_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1404736_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1404774_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376178_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376181_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376179_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376179_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376180_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376179_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376188_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376179_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376189_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376182_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376181_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1404736_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376182_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376187_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376184_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376186_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376185_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376188_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376186_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376189_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376187_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1416392_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376190_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376190_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1416368_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376193_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376191_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376191_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376192_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376191_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376199_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376191_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376200_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376194_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376193_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1416368_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376194_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376198_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376195_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376197_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376196_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376199_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376197_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376200_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376198_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376201_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1416358_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1416370_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376201_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376239_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376202_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376202_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1393367_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376205_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376203_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376203_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376204_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376203_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376212_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376203_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376213_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376206_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376205_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1393367_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376206_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376211_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376208_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376210_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376209_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376212_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376210_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376213_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376211_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376217_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376215_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376215_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376216_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376215_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376224_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376215_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376225_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376218_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376217_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405547_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376218_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376223_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376220_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376222_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376221_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376224_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376222_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376225_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376223_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376228_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376238_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376229_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376228_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405359_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376229_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376236_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405951_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405706_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376236_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376238_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1376239_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1376284_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376342_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1410567_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376284_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376338_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376285_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376285_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376343_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376343_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376286_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376286_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1418318_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376289_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376287_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376287_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376288_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376287_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376296_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376287_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376297_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376290_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376289_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1418318_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376290_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376295_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376292_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376294_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376293_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376296_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376294_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376297_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376295_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376301_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376299_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376299_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376300_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376299_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376307_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376299_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376308_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376302_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376301_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_2408005_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376302_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376306_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376303_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376305_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376304_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376307_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376305_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376308_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376306_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376347_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376310_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376310_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1418578_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376313_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376311_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376311_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376312_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376311_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376320_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376311_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376321_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376314_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376313_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1418578_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376314_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376319_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376316_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376318_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376317_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376320_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376318_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376321_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376319_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376322_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1418071_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1418226_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376322_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376325_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376323_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376323_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376324_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376323_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376332_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376323_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376333_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376326_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376325_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1418071_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376326_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376331_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376328_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376330_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376329_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376332_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376330_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376333_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376331_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376336_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376346_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376337_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376336_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1411172_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376337_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1406624_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376338_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376339_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1418320_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1406654_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376339_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376339_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_2408008_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376340_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376341_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1406487_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376340_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376341_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_2408005_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376342_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376344_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376344_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1418226_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1376346_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1376347_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1377153_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1376776_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1376776_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1851061_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1377176_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1377169_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1377169_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1377187_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1377187_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1377180_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1377180_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1377197_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1377197_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1406656_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1377445_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1377857_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1377873_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1377445_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1377872_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1377873_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1377887_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1377872_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1379215_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1379214_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1379214_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1415898_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1440007_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1379274_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1379274_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1393248_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1379315_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1380331_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1651917_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1379315_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1379362_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1406159_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1651025_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1379362_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1379376_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1444952_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1650973_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1379376_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1379408_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405360_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1445132_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1379408_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1379630_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1379456_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1394374_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1379480_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1406340_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1379501_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1406247_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1379521_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1379579_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1379557_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1394252_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1379557_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1379557_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1379630_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1380587_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1380555_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1380585_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1380587_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1404124_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1380585_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1380983_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1380670_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1380981_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1380983_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1398600_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1385123_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1385123_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1393153_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1385143_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1402543_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1402651_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1385143_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1402954_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1392911_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1392911_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1402935_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1393153_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1393155_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1393155_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1398432_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1403831_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1393240_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1393240_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403685_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1393248_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403820_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1444255_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1394252_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1394327_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1394287_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1394348_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1394287_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1394287_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1394374_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1444225_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1394327_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1394422_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405642_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1465946_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1394422_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405642_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1394423_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1394423_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405707_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1394423_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1416370_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1402545_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1402524_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1402543_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1402545_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1402956_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1402954_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1501772_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1402956_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1403186_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1403229_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1403229_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1403227_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1403721_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403723_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403723_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403830_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403820_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403831_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403820_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403913_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403898_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403951_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1403951_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1403949_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1404202_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1404124_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1404201_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1404190_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1404190_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1404202_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1404475_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405058_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405057_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1404475_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1404817_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1404774_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405058_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1404817_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405191_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405057_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405191_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405359_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405360_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405191_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405963_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405547_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405608_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405706_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405707_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405608_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1405951_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1405963_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1406159_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1405992_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1406225_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1405992_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1405992_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1406247_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1444952_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1406008_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1406353_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1406008_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1406008_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1406340_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_2408008_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1406487_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1418320_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1406624_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1406647_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1406654_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1406661_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1406647_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1406656_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_2435132_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1410668_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1406661_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1410521_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1410567_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1418012_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1410521_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1411098_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1410668_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1410817_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1411172_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1418571_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1410817_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1411694_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1411098_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1411776_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1411694_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1411694_4 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1418012_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_2435134_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1411776_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1412924_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829867_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1414522_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1414515_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1414515_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1913311_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1913311_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1414636_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1414636_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1914479_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1415898_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1900998_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1416358_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1416394_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1416394_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1416392_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_2435134_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1418571_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1426524_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1426522_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1446453_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1426524_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1426649_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1426647_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1438025_0 | SINK | DUCT | USERDEFINED | Meccanico Aria esterna 1
OutPort_1426740_1 | SOURCE | DUCT | USERDEFINED | Meccanico Aria esterna 1
InPort_1426740_5 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
OutPort_1433074_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 25
InPort_1426740_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1463342_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1437991_0 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 1
OutPort_1426740_7 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 1
InPort_2354815_1 | SINK | DUCT | USERDEFINED | Meccanico Aria esterna 2
OutPort_1427203_1 | SOURCE | DUCT | USERDEFINED | Meccanico Aria esterna 2
InPort_1427203_5 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_2354805_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1427203_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_2354821_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_2354833_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1427203_7 | SOURCE | DUCT | EXHAUST | Meccanico Aria di ritorno 19 (1)
InPort_1599777_0 | SINK | DUCT | EXHAUST | Meccanico Aria esterna 6
OutPort_1427229_1 | SOURCE | DUCT | USERDEFINED | Meccanico Aria esterna 6
InPort_1427229_5 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_2354807_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1427229_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_2354823_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1599979_0 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 7
OutPort_1427229_7 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 7
InPort_1590520_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_1427356_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_1473295_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1427356_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1427356_4 | SINK | DUCT | EXHAUST | Meccanico Aria di ritorno 1
OutPort_1591506_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1427356_5 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1590544_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di mandata 2
InPort_1474612_0 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1427368_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1473823_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1427368_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1427368_4 | SINK | DUCT | EXHAUST | Meccanico Aria di ritorno 6
OutPort_1591563_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1427368_5 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1472167_0 | SOURCE | DUCT | EXHAUST | Meccanico Aria di mandata 7
InPort_1432486_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1428050_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1428231_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1431266_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432685_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1428231_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1610559_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1429329_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1429329_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1610562_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1429329_10 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432772_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1429329_11 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432793_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1430520_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1430522_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432718_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1431148_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434115_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432463_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434071_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432486_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432678_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432685_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432773_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432678_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432689_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432773_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432772_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432689_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432733_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432718_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432726_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432733_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432794_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432726_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432737_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432794_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432793_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432737_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1610562_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432865_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432865_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1432907_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432865_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434169_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432865_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434190_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1433012_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
OutPort_1437319_8 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 25
InPort_1433356_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
OutPort_1433012_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 25
InPort_1433074_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
OutPort_1433356_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 25
InPort_1433841_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1610559_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1463588_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1433841_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1463464_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1433853_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1433853_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1463588_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434086_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434071_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434079_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434086_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434170_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434079_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434090_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434170_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434169_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434090_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434130_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434115_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434123_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434130_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434191_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434123_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434134_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434191_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1434190_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1434134_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
Port_1434220_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499743_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434220_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499746_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434229_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499743_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434229_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434378_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434251_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_2406462_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434251_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500862_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434262_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434378_3 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434262_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_2406462_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1434378_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1437326_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1436722_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646329_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1436722_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646332_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1436739_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646308_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1436739_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646311_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1437319_9 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1437928_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1437319_10 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646175_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1437319_11 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646151_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1437326_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1437928_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
InPort_1588828_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 1
OutPort_1437991_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 1
InPort_1438145_1 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 1
OutPort_1438025_1 | SOURCE | DUCT | USERDEFINED | Meccanico Aria esterna 1
InPort_1438340_0 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 3
OutPort_1438236_1 | SOURCE | DUCT | USERDEFINED | Meccanico Aria esterna 3
InPort_1438236_5 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
OutPort_1438261_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 8
InPort_1438236_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1463145_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438339_0 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 2
OutPort_1438236_7 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 2
InPort_1438248_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438237_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438237_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438587_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
