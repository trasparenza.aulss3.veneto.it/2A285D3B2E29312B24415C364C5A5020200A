Properties of the parts of a building model (IFC4), part 4 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1248599_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1632712_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1248849_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1248599_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1251826_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1248849_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1248994_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1248999_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1248998_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1248994_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1248996_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1248998_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1249018_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1249013_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1249013_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1249017_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1249017_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1249015_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1249179_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1249180_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1249180_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250049_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250049_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1249182_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1249182_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250050_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1249820_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1249821_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1249821_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250916_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250916_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1249823_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1249823_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250917_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250196_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1249849_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1249927_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250806_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1251251_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1249927_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1251253_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1249927_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1249932_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1251251_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1249977_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1251253_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250042_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1249977_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250041_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1577736_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250050_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250041_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1577736_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250042_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250119_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833282_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1250138_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1250119_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1250127_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1250138_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1250147_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1250127_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1252849_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1250147_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1833282_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1250196_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1251743_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1250758_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1250804_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1253133_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1251618_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250804_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1251620_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250804_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250806_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1251618_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250848_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1251620_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250911_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250848_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250910_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1577745_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1250917_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250910_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1577745_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1250911_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1833264_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1251711_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1251711_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1251727_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1251727_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1251722_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1251722_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833265_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1833265_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1251743_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1251843_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1251826_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1251826_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833423_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1251836_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833716_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1257574_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1251836_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1251836_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1258391_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1252452_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1251843_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1252993_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1251877_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1251877_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1251893_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2435079_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1251886_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1251886_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1257028_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1251893_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2435074_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1833463_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1252452_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1833390_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1252847_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1252847_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833342_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1833342_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1252849_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1252849_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833264_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1252986_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1252993_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1253283_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1252986_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1252988_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1253283_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1253284_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1252988_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1253062_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1253284_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1253243_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1253062_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1253062_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1920625_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1920627_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1253062_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1253133_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1253243_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1253446_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1253803_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256066_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1253525_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1253525_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1558874_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1253803_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1255846_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1834221_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1254104_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1254104_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1834218_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1254104_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1834220_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1254199_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1834221_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1265320_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1254199_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1254239_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833914_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1834148_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1254239_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1254885_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1254456_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255471_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1254481_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1254481_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255015_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1254844_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1631243_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1631240_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1254844_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255015_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1254885_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255466_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255471_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255470_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255466_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1631243_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255468_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255468_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255470_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255658_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255649_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255666_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255650_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255650_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255660_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255652_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1258372_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1258393_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255652_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255660_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255658_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255662_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255666_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255665_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255662_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1258372_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255663_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255663_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1255665_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1255814_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1255817_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1255817_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256235_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1255846_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256071_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256235_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1255993_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1255993_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256236_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256071_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256066_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256156_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256066_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256230_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256156_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256229_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256230_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256236_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256229_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1558874_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256577_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256577_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1558883_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256577_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1920130_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1920132_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1256577_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1265524_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256780_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256780_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1265525_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1256819_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1265524_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1557150_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1256819_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1257028_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2435841_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1257664_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1257028_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1257536_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1257574_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1257584_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1257536_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1257577_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1257584_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1258124_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1257577_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1257682_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1257664_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1257675_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1257682_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1265525_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1257675_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1833914_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1258102_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1258102_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1258124_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1258226_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2435099_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1833716_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1258226_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1258391_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1258383_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1258383_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1258393_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1259450_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864174_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1864175_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1259450_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435029_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1259713_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1833814_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1259997_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1259997_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1834096_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1260446_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1265320_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266306_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1260446_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1261950_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1466595_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1261952_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1261950_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1466958_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1261952_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1864174_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1261965_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1261965_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1835067_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1261967_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1835064_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1835067_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1261967_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1262037_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263190_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262042_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262043_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262043_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263098_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263098_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262046_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262046_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263099_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262047_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2435708_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263653_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262047_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263655_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262047_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262048_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263653_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263431_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262048_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262065_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1557025_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2470199_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262065_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262065_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1920041_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1920043_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1262065_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2436334_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262066_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262066_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2436329_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262069_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2436334_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262871_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262069_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262384_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1557150_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1558883_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262384_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1557025_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262745_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1262745_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1262871_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263035_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263655_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263093_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263035_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263092_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263093_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263099_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263092_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263190_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263575_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263427_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263428_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263428_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263438_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263438_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263430_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263430_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263439_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263530_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263431_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263435_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263431_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263437_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263435_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263436_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263437_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263439_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263436_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263575_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1263530_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1263794_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1263789_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1263953_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1263794_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1263851_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1263848_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1264274_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1263851_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266097_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1263953_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1265601_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1264274_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1264470_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1264466_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1264474_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1264470_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1265842_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1264474_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1264903_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1265365_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1834218_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1264903_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1264903_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266112_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1265365_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266235_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266233_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1265601_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1265927_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1265842_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1834220_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1265916_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1265916_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1265927_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266113_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266097_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266112_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266106_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266106_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266113_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266226_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266233_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266242_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266226_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266235_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266242_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266296_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266306_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266342_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266296_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266310_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266342_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1266341_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266310_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435029_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1266341_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1268711_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1818054_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268737_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1813037_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268746_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271015_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268755_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1809992_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268764_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271009_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268773_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1811174_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268813_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1817866_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268814_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1813040_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268815_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1817761_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268816_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271033_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268817_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271036_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268818_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1817957_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271068_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268852_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268852_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268867_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268867_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269009_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268876_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269256_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268891_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268876_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268886_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268891_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272672_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268886_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1817991_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268914_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268914_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268981_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268934_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269282_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268949_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268934_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268944_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268949_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272698_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268944_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268981_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1810191_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269558_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268981_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810196_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1268983_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1268983_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332390_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269007_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1813687_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269009_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269007_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269470_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269007_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1814380_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269034_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269034_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1814381_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269256_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1809933_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1270369_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269256_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810154_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269258_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269258_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1327133_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269282_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269284_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1270351_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269282_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269284_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1326959_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271421_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269470_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1332245_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269486_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269486_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1331006_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1816746_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269524_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269524_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1331152_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1816770_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269540_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1269540_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1331152_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1817826_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1269558_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272623_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1270351_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272503_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1270369_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271009_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272738_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271015_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272206_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271033_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272646_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271036_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272717_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271061_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271068_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1811413_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271061_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271267_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1817991_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1811759_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271267_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271414_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271421_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271440_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271414_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1818054_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271440_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271784_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1817826_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271818_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271784_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1817866_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271818_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271835_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332245_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1813413_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271835_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1271864_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1816770_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1813175_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1271864_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272124_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1816746_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272156_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272124_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1817761_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272156_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272180_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1837201_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272206_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272180_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272496_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272503_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810014_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272496_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272616_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272623_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272646_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272616_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272663_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272672_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272738_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272663_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272689_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272698_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272717_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272689_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1281537_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272800_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272800_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272877_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1281554_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1272831_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1272831_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_2406632_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1272877_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1272866_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1272866_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1474158_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1321657_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1275845_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1275845_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1275965_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1275845_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280041_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1275887_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321657_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321660_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1275887_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1276196_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1276308_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321800_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1276196_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1276308_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1276244_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1276244_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1276277_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1276244_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280381_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1276334_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1808973_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1810711_10 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1276334_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277069_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1810338_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321053_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277069_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1320904_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277070_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277070_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277073_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277070_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280847_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1320946_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277294_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277294_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277297_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277294_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1279820_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277320_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1320946_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1320958_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277320_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277853_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277788_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277788_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277790_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277788_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1279174_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277969_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277853_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1813877_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277969_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1277972_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1320859_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321273_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1277972_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1278273_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1810688_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322073_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1278273_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322075_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1278282_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1278282_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1278304_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1278282_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280231_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1279160_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1279090_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1279174_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1279160_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1279808_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1279764_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1279820_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1279808_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1280030_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280008_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1280041_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280030_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1280219_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280199_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1280231_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280219_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1280374_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280358_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1280381_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280374_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1280813_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280677_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1280847_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1280813_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322338_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1281064_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1281064_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1281065_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1281064_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1281074_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1281070_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1812036_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322433_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1281070_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1281073_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1281072_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1281074_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1281073_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1776732_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1281537_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1281539_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1819531_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1819533_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1281539_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1281556_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1281554_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1654593_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1281556_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1281631_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1814638_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1814640_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1281631_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1283099_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283632_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283100_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283629_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1378867_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283269_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283269_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283505_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1292283_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283277_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283277_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1303656_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283314_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1284099_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283506_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283314_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283524_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283314_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283505_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283319_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283319_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283506_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283353_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283524_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1378912_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1283353_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283629_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1378867_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1283632_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1378912_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1284097_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1287355_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1284286_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1284097_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1284099_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1284286_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1299496_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284336_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284336_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1906063_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284336_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1905958_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284436_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284367_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1377857_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284434_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284434_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284438_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284438_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284436_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284436_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284742_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284436_7 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284764_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284764_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284592_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
