Properties of the parts of a building model (IFC4), part 1 of 17

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 8d1c7a51-dfe9-4485-b0f7-9500dc939aa3, NumberOfSaves: 115], CoordinateReference [CoordinateBase: Coordinate condivise, ProjectSite: Planimetria di default]
File name: 07324
Time: 2025-02-28T18:22:35+01:00
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.11.26 (ITA) - IFC 24.1.11.26

# IfcProject: Ospedale di Dolo (VE), 07324
Description: PROGETTAZIONE ESECUTIVA DI N° 6 SALE OPERATORIE AL 3° PIANO BLOCCO EST OD 03D OSPEDALE DI DOLO (VE) - MODELLO ELETTRICO; LongName: 07324_DOLO_PE_HVAC_01; Phase: ESECUTIVO

# IfcSite: Ospedale di Dolo (VE)
Description: Via Louis Pasteur, 11, 30031 Dolo VE; LongName: Piano terzo pronto soccorso ospedale di Dolo; RefLatitude: 45, 25, 19, 889831; RefLongitude: 12, 4, 4, 325637; RefElevation: 0 mm

# IfcBuildingStorey: Livello:Estremità 8 mm (7)
Name | LongName | Elevation (mm)
A-I1-FIN | A-I1-FIN | -3700
A-TR-FIN | A-TR-FIN | 0
A-01-FIN | A-01-FIN | 3690
A-02-FIN | A-02-FIN | 7380
A-03-FIN | A-03-FIN | 11910
A-04-FIN | A-04-FIN | 16610
A-CP-FIN | A-CP-FIN | 20980

# IfcAirTerminal: Bocchettoni : Bocchetta di mandata : Adjustable Shutter (10)
Type - PredefinedType: GRILLE; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Bocchetta di mandata
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Bocchetta di mandata aria
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: VEN24-12.02.03.01
Abaco IFCGUID - Famiglia e tipo: Bocchetta di mandata: Adjustable Shutter; WBS_01: DBE; WBS_02: IM
Name (Bocchettoni : Bocchetta di mandata :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Group
 Adjustable Shutter | A-03-FIN | P03 | Meccanico Aria di mandata 2
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria esterna 1
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria esterna 3
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria esterna 4
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria esterna 7
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria esterna 9
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria esterna 8
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria esterna 2
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria esterna 5
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria esterna 6

# IfcAirTerminal: Bocchettoni : Diffusore ad effetto elicoidale mandata : RFD-R-D-A/200 (19)
In: A-03-FIN
Type - PredefinedType: DIFFUSER; Material: Color RGB 245-245-245, Color RGB 078-078-078
Pset Descrizione_Entità - Descrizione_Entità: Diffusore Elicoidale di mandata
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Diffusore elicoidale mandata
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: VEN24-12.02.33.01-02
Abaco IFCGUID - Famiglia e tipo: Diffusore ad effetto elicoidale mandata: RFD-R-D-A/200; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di mandata 2

# IfcAirTerminal: Bocchettoni : Diffusore ad effetto elicoidale mandata : RFD-R-D-A/250 (18)
In: A-03-FIN
Type - PredefinedType: DIFFUSER; Material: Color RGB 245-245-245, Color RGB 078-078-078
Pset Descrizione_Entità - Descrizione_Entità: Diffusore Elicoidale di mandata
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Diffusore elicoidale mandata
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: VEN24-12.02.33.01-02
Abaco IFCGUID - Famiglia e tipo: Diffusore ad effetto elicoidale mandata: RFD-R-D-A/250; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di mandata 2

# IfcAirTerminal: Bocchettoni : Diffusore ad effetto elicoidale ripresa : RFD-R-D-A/200 (14)
In: A-03-FIN
Type - PredefinedType: DIFFUSER; Material: Color RGB 245-245-245, Color RGB 078-078-078
Pset Descrizione_Entità - Descrizione_Entità: Diffusore Elicoidale di ripresa
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Diffusore elicoidale ripresa
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: VEN24-12.02.33.01-02
Abaco IFCGUID - Famiglia e tipo: Diffusore ad effetto elicoidale ripresa: RFD-R-D-A/200; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di ritorno 1

# IfcAirTerminal: Bocchettoni : Diffusore ad effetto elicoidale ripresa : RFD-R-D-A/250 (21)
In: A-03-FIN
Type - PredefinedType: DIFFUSER; Material: Color RGB 245-245-245, Color RGB 078-078-078
Pset Descrizione_Entità - Descrizione_Entità: Diffusore Elicoidale di ripresa
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Diffusore elicoidale ripresa
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: VEN24-12.02.33.01-02
Abaco IFCGUID - Famiglia e tipo: Diffusore ad effetto elicoidale ripresa: RFD-R-D-A/250; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di ritorno 1

# IfcAirTerminal: Bocchettoni : Diffusore forellinato mandata - Filtro H14 : 600x600 (38)
In: A-03-FIN
Type - PredefinedType: DIFFUSER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Diffusore forellinato mandata - Filtro H14
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Diffusore forellinato per mandata aria H14
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: M04.ipf.001
Abaco IFCGUID - Famiglia e tipo: Diffusore forellinato mandata - Filtro H14: 600x600; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Bocchettoni : Diffusore forellinato mandata - Filtro H14 :...) | Group
23 x  600x600 | Meccanico Aria di mandata 2
14 x  600x600 | Meccanico Aria di mandata 7
 600x600

# IfcAirTerminal: Bocchettoni : Diffusore forellinato ripresa : 600x600 (26)
In: A-03-FIN
Type - PredefinedType: DIFFUSER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Diffusore forellinato ripresa
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Diffusore forellinato per ripresa aria
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: 035274b
Abaco IFCGUID - Famiglia e tipo: Diffusore forellinato ripresa: 600x600; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Bocchettoni : Diffusore forellinato ripresa :...) | Group
22 x  600x600 | Meccanico Aria di ritorno 1
2 x  600x600
2 x  600x600 | Meccanico Aria di ritorno 6

# IfcAirTerminal: Bocchettoni : Griglia di ripresa : Adjustable Shutter (65)
Type - PredefinedType: GRILLE; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Griglia di ripresa
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Griglia di ripresa aria
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: VEN24-12.02.38.01-04
Abaco IFCGUID - Famiglia e tipo: Griglia di ripresa: Adjustable Shutter; WBS_01: DBE; WBS_02: IM
Name (Bocchettoni : Griglia di ripresa :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Group
7 x  Adjustable Shutter | A-03-FIN | P03 | Meccanico Aria di ritorno 6
 Adjustable Shutter | A-03-FIN | P03 | Meccanico Aria di ritorno 1
8 x  Adjustable Shutter | A-03-FIN | P03 | Meccanico Aria di ritorno 9
8 x  Adjustable Shutter | A-03-FIN | P03 | Meccanico Aria di ritorno 14
8 x  Adjustable Shutter | A-03-FIN | P03 | Meccanico Aria di ritorno 15
8 x  Adjustable Shutter | A-03-FIN | P03 | Meccanico Aria di ritorno 19 (1)
8 x  Adjustable Shutter | A-03-FIN | P03 | Meccanico Aria di ritorno 17
8 x  Adjustable Shutter | A-03-FIN | P03 | Meccanico Aria di ritorno 22
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria di scarico 2
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria di scarico 3
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria di scarico 5
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria di scarico 11
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria di scarico 9
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria di scarico 1
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria di scarico 4
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria di scarico 6
 Adjustable Shutter | A-04-FIN | PC | Meccanico Aria di scarico 7

# IfcAirTerminal: Bocchettoni : SC_Air filtration ceiling for Operating Theatre : DIF-OT 5/435 - 2,4 x 2,4 m (3)
In: A-03-FIN
Type - PredefinedType: DIFFUSER; Material: SC_Stainless Steel AISI 304_RAL9010
Pset Descrizione_Entità - Descrizione_Entità: Air filtration ceiling for Operating Theatre
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Plafone immissione aria con filtro H14
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M16.lso.001-003
Abaco IFCGUID - Famiglia e tipo: SC_Air filtration ceiling for Operating Theatre: DIF-OT 5/435 - 2,4 x 2,4 m; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Bocchettoni : SC_Air filtration ceiling for Operating Theatre :...) | Group
 DIF-OT 5/435 - 2,4 x 2,4 m | Meccanico Aria di mandata 32 (1)
 DIF-OT 5/435 - 2,4 x 2,4 m | Meccanico Aria di mandata 34
 DIF-OT 5/435 - 2,4 x 2,4 m | Meccanico Aria di mandata 19 (1)

# IfcAirTerminal: Bocchettoni : SC_Air filtration ceiling for Operating Theatre : DIF-OT 5/555 - 3,0 x 3,0 m (3)
In: A-03-FIN
Type - PredefinedType: DIFFUSER; Material: SC_Stainless Steel AISI 304_RAL9010
Pset Descrizione_Entità - Descrizione_Entità: Air filtration ceiling for Operating Theatre
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Plafone immissione aria con filtro H14
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M16.lso.001-003
Abaco IFCGUID - Famiglia e tipo: SC_Air filtration ceiling for Operating Theatre: DIF-OT 5/555 - 3,0 x 3,0 m; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Bocchettoni : SC_Air filtration ceiling for Operating Theatre :...) | Group
 DIF-OT 5/555 - 3,0 x 3,0 m | Meccanico Aria di mandata 5; Meccanico Aria di mandata 4
 DIF-OT 5/555 - 3,0 x 3,0 m | Meccanico Aria di mandata 14; Meccanico Aria di mandata 13
 DIF-OT 5/555 - 3,0 x 3,0 m | Meccanico Aria di mandata 18; Meccanico Aria di mandata 15

# IfcAirTerminal: Bocchettoni : Valvola estrazione WC : KK-150 (10)
In: A-03-FIN
Type - PredefinedType: DIFFUSER; Material: Acciaio, Finitura RAL 9010
Pset Descrizione_Entità - Descrizione_Entità: Valvola di estrazione aria WC
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Valvola di estrazione aria WC
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.76.02
Abaco IFCGUID - Famiglia e tipo: Valvola estrazione WC: KK-150; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di ritorno 1

# IfcAirTerminalBox: Accessori per condotti : Regolatore di portata rettangolare CAV : 200x100 (34)
In: A-03-FIN
Type - PredefinedType: CONSTANTFLOW; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Volume flow rate controller for constant volume system
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M18.edp.101-102
Pset Main Dimensions - Main Dimensions: 200x100
Abaco IFCGUID - Famiglia e tipo: Regolatore di portata rettangolare CAV: 200x100; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Regolatore di portata rettangolare CAV :...) | Group
20 x  200x100 | Meccanico Aria di ritorno 1
14 x  200x100 | Meccanico Aria di mandata 2

# IfcAirTerminalBox: Accessori per condotti : Regolatore di portata rettangolare CAV : 300x100 (32)
In: A-03-FIN
Type - PredefinedType: CONSTANTFLOW; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Volume flow rate controller for constant volume system
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M18.edp.101-102
Abaco IFCGUID - Famiglia e tipo: Regolatore di portata rettangolare CAV: 300x100; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Regolatore di portata rettangolare CAV :...) | Group
 300x100 | Meccanico Aria di ritorno 1 | AB_ProperySet - IFC_Descriptions: CAV
13 x  300x100 | Meccanico Aria di mandata 2
18 x  300x100 | Meccanico Aria di ritorno 1

# IfcAirTerminalBox: Accessori per condotti : Regolatore di portata rettangolare CAV : 300x150 (17)
In: A-03-FIN
Type - PredefinedType: CONSTANTFLOW; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Volume flow rate controller for constant volume system
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M18.edp.101-102
Abaco IFCGUID - Famiglia e tipo: Regolatore di portata rettangolare CAV: 300x150; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Regolatore di portata rettangolare CAV :...) | Group
5 x  300x150 | Meccanico Aria di ritorno 1
10 x  300x150 | Meccanico Aria di mandata 2
 300x150 | Meccanico Aria di ritorno 6
 300x150 | Meccanico Aria di mandata 7

# IfcAirTerminalBox: Accessori per condotti : Regolatore di portata rettangolare CAV : 300x200 (11)
In: A-03-FIN
Type - PredefinedType: CONSTANTFLOW; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Volume flow rate controller for constant volume system
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M18.edp.101-102
Abaco IFCGUID - Famiglia e tipo: Regolatore di portata rettangolare CAV: 300x200; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Regolatore di portata rettangolare CAV :...) | Group
4 x  300x200 | Meccanico Aria di mandata 2
 300x200 | Meccanico Aria di ritorno 1
6 x  300x200 | Meccanico Aria di mandata 7

# IfcAirTerminalBox: Accessori per condotti : Regolatore di portata rettangolare CAV : 400x200 (7)
In: A-03-FIN
Type - PredefinedType: CONSTANTFLOW; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Volume flow rate controller for constant volume system
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M18.edp.101-102
Abaco IFCGUID - Famiglia e tipo: Regolatore di portata rettangolare CAV: 400x200; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di ritorno 6

# IfcCoil: Attrezzatura meccanica : Batteria Postriscaldamento : Batteria Postriscaldamento (28)
In: A-03-FIN
Type - PredefinedType: WATERHEATINGCOIL; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Batteria di post-riscaldamento
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Batteria idronica a canale
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M02.adp.001-006
Abaco IFCGUID - Famiglia e tipo: Batteria Postriscaldamento: Batteria Postriscaldamento; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di mandata 2; Mandata Post 2 (1) (1); Ritorno Post 1 (1) (1)

# IfcDamper: Accessori per condotti : Serranda di regolazione rettangolare : 400 x 200 (12)
In: A-03-FIN
Type - PredefinedType: CONTROLDAMPER; Material: <Unnamed>
Classification: D3090 Uniformat (Uniformat)
Pset Descrizione_Entità - Descrizione_Entità: Serranda di regolazione rettangolare
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda di regolazione ripresa sala operatoria
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 035295b
Abaco IFCGUID - Famiglia e tipo: Serranda di regolazione rettangolare: 400 x 200; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda di regolazione rettangolare :...) | Group
4 x  400 x 200 | Meccanico Aria di ritorno 17
4 x  400 x 200 | Meccanico Aria di ritorno 22
4 x  400 x 200 | Meccanico Aria di ritorno 19 (1)

# IfcDamper: Accessori per condotti : Serranda di regolazione rettangolare : 400 x 400 (12)
In: A-03-FIN
Type - PredefinedType: CONTROLDAMPER; Material: <Unnamed>
Classification: D3090 Uniformat (Uniformat)
Pset Descrizione_Entità - Descrizione_Entità: Serranda di regolazione rettangolare
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda di regolazione ripresa sala operatoria
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 035297c
Abaco IFCGUID - Famiglia e tipo: Serranda di regolazione rettangolare: 400 x 400; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda di regolazione rettangolare :...) | Group
4 x  400 x 400 | Meccanico Aria di ritorno 14
4 x  400 x 400 | Meccanico Aria di ritorno 9
4 x  400 x 400 | Meccanico Aria di ritorno 15

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 200x150 (16)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda tagliafuoco rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Pset Main Dimensions - Main Dimensions: 200x150
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 200x150; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda tagliafuoco rettangolare :...) | Group
8 x  200x150 | Meccanico Aria di ritorno 1
8 x  200x150 | Meccanico Aria di mandata 2

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 200x200 (2)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda tagliafuoco rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Pset Main Dimensions - Main Dimensions: 200x200
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 200x200; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda tagliafuoco rettangolare :...) | Group
 200x200 | Meccanico Aria di ritorno 6
 200x200 | Meccanico Aria di mandata 7

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 250x150 (4)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda tagliafuoco rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Pset Main Dimensions - Main Dimensions: 250x150
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 250x150; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda tagliafuoco rettangolare :...) | Group
2 x  250x150 | Meccanico Aria di ritorno 1
2 x  250x150 | Meccanico Aria di mandata 2

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 300x200 (5)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda tagliafuoco rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 300x200; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda tagliafuoco rettangolare :...) | Group
2 x  300x200 | Meccanico Aria di ritorno 1
3 x  300x200 | Meccanico Aria di mandata 2

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 400x200
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 400x200; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di mandata 2

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 450x450 (2)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 450x450; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di ritorno 1

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 500x250 (3)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 500x250; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda tagliafuoco rettangolare :...) | Group
2 x  500x250 | Meccanico Aria di mandata 2
 500x250 | Meccanico Aria di ritorno 1

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 500x300
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 500x300; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di ritorno 1

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 500x500 (2)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 500x500; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di mandata 2

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 550x500 (6)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 550x500; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda tagliafuoco rettangolare :...) | Group
2 x  550x500 | Meccanico Aria di mandata 2
2 x  550x500 | Meccanico Aria di ritorno 22
2 x  550x500 | Meccanico Aria di mandata 19 (1)

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 550x550 (2)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Regolatore di portata costante rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 550x550; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di ritorno 1

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 700x400
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda tagliafuoco rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 700x400; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di mandata 2

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 700x450 (2)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda tagliafuoco rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 700x450; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda tagliafuoco rettangolare :...) | Group
 700x450 | Meccanico Aria di mandata 7
 700x450 | Meccanico Aria di ritorno 6

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 700x500 (2)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda tagliafuoco rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 700x500; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Aria di ritorno 1

# IfcDamper: Accessori per condotti : Serranda tagliafuoco rettangolare : 800x600 (2)
In: A-03-FIN
Type - PredefinedType: FIREDAMPER; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Serranda tagliafuoco
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Serranda tagliafuoco rettangolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.57.01-03
Abaco IFCGUID - Famiglia e tipo: Serranda tagliafuoco rettangolare: 800x600; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Accessori per condotti : Serranda tagliafuoco rettangolare :...) | Group
 800x600 | Meccanico Aria di mandata 2
 800x600 | Meccanico Aria di ritorno 1

# IfcDistributionPort (11772)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1204470_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1047473_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1057131_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1089384_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1065681_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1165809_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1165782_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1065681_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1065681_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972819_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972821_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1065681_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1239507_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1069096_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1070376_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1896799_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1087639_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1165782_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1165207_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1087639_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1089384_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1165636_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1090874_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1090911_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1090911_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1165662_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1090921_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1090930_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1165662_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1090921_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1090930_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1161350_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1090931_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1090930_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1165636_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1090931_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1164443_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1161158_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1915874_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1161193_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1161350_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167537_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1161406_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173876_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1165809_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1161406_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1507020_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1164443_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1167520_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1165207_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1167679_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1165240_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1165240_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1170858_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1166694_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1507020_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1507036_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1166694_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1166908_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1506924_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1506944_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1166908_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1166961_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173800_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173775_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1166961_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1167547_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167520_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1167542_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167527_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1167527_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167547_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1167537_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167536_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1167536_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167542_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1504724_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1167620_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1167620_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173775_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1167674_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167679_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1167678_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167674_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1173893_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167676_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1167676_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1167678_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1168041_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1826407_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1168044_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173625_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1826414_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1168044_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1174189_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1169286_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1169286_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1174190_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1169373_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1169372_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2358679_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1169373_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2471119_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1170002_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1170002_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2111709_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1170269_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1170270_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1170270_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173507_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1170582_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359413_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2471715_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1170582_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1170724_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1170582_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2471799_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1170587_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1170587_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2471800_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1173508_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1170724_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1170858_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1181128_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1174190_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1170858_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1173533_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1171400_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1171400_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2472404_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1171622_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2471157_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1826503_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1171622_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1171622_5 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1826505_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1171622_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1826507_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1826505_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1171801_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1171801_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173735_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1172098_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1174189_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1174035_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1172098_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1172098_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972907_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972909_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1172098_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2359411_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1172170_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1172170_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1174035_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2111709_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173458_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173458_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173462_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173460_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2358667_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173462_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173460_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173507_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173530_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2472391_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173508_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1173528_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173533_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1173532_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173528_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1173530_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173532_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1173625_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173620_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1173620_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2471799_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1504721_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173723_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173723_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1504724_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173723_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2360471_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173724_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1504721_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173735_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173724_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173800_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173794_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173794_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1505613_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1505613_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1173796_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173796_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1507033_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173796_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1506940_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1173876_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173874_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1173874_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1173893_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1174774_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1174773_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1174778_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1174774_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1175138_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1174778_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1174818_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1175141_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1174841_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1174818_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1826507_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1174826_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1174826_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1174841_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1175141_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1175136_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1175136_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1175140_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1175140_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1175138_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176241_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1792306_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205381_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176241_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176241_12 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202191_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176241_15 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202318_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1206566_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176362_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1180859_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176455_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176455_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1803110_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176507_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176510_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176508_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176542_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1794801_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176508_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176508_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972743_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972745_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1176508_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1176509_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1794801_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1794802_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176509_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176510_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176537_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176512_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176513_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176513_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176539_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176515_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176516_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176539_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176515_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176516_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176520_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176517_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176516_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176537_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176517_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176522_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176518_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176524_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176519_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176520_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176562_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176521_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176612_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176542_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176521_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176591_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176522_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176593_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176524_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183050_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176531_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176531_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1788682_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176603_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176549_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176551_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176550_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176550_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176591_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176603_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176551_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176553_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176552_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176552_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176593_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176603_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176553_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176554_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176606_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176601_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176554_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1794735_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176558_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176558_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1794802_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176565_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176560_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176560_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1794735_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176562_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176561_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176561_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176565_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1185103_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176572_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176572_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176601_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176573_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1183050_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176576_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176573_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176613_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176574_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176574_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176576_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176606_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176602_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176602_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1505348_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1505348_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176603_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176612_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176611_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176611_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176613_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176649_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176652_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176650_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179150_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179152_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176650_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176650_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971760_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971762_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1176650_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1176651_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179152_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176672_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176651_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176652_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1177710_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176654_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176655_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176655_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1177712_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176657_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176658_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1177712_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176657_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176658_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176662_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176659_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176658_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1177710_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176659_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176664_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176660_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176666_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176661_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176662_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176704_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176663_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179075_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179150_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176663_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1178726_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176664_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1178729_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176666_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176700_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176672_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176745_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176691_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1178494_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176692_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176692_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1178726_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1178495_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176694_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176694_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1178729_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176696_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190296_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190297_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176696_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176710_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176700_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176707_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176702_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176702_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176710_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
