Properties of the parts of a building model (IFC4), part 16 of 17

# IfcDuctFitting: Raccordi condotto : M_Giunto rettangolare - Smussato : Standard (173)
Abaco IFCGUID - Famiglia e tipo: M_Giunto rettangolare - Smussato: Standard; WBS_01: DBE; WBS_02: IM
Name (Raccordi condotto : M_Giunto rettangolare - Smussato :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | IFC_Descriptions | Group
42 x  Standard | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di ritorno 1
33 x  Standard | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di ritorno 1
14 x  Standard | A-03-FIN | P03 | UTA.03.09 | Meccanico Aria di ritorno 6
8 x  Standard | A-03-FIN | P03 | UTA.03.06 | Meccanico Aria di ritorno 9
8 x  Standard | A-03-FIN | P03 | UTA.03.05 | Meccanico Aria di ritorno 14
8 x  Standard | A-03-FIN | P03 | UTA.03.04 | Meccanico Aria di ritorno 15
2 x  Standard | A-03-FIN | P03 | UTA.03.01 | Meccanico Aria di mandata 19 (1)
10 x  Standard | A-03-FIN | P03 | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
10 x  Standard | A-03-FIN | P03 | UTA.03.02. | Meccanico Aria di ritorno 17
10 x  Standard | A-03-FIN | P03 | UTA.03.01 | Meccanico Aria di ritorno 22
2 x  Standard | A-03-FIN | P03 | UTA.03.03 | Meccanico Aria di mandata 32 (1)
2 x  Standard | A-03-FIN | P03 | UTA.03.02. | Meccanico Aria di mandata 34
4 x  Standard | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di ritorno 9
4 x  Standard | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di ritorno 14
4 x  Standard | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di ritorno 15
 Standard | A-04-FIN | PC | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
 Standard | A-04-FIN | PC | UTA.03.02. | Meccanico Aria di ritorno 17
 Standard | A-04-FIN | PC | UTA.03.08 | Meccanico Aria di mandata 2
 Standard | A-04-FIN | PC | UTA.03.08 | Meccanico Aria di ritorno 1
 Standard | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di mandata 2
3 x  Standard | A-03-FIN | P03 |  | Meccanico Aria di ritorno 1
 Standard | A-03-FIN | P03 |  | Meccanico Aria di ritorno 22
3 x  Standard | A-03-FIN | P03 |  | Meccanico Aria di mandata 2

# IfcDuctFitting: Raccordi condotto : M_Gomito rettangolare - Raggio : 0.6 W (429)
Type - PredefinedType: CONNECTOR; Classification: 5.1.4 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Curva condotto rettangolare
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: M_Gomito rettangolare - Raggio: 0.6 W; WBS_01: DBE; WBS_02: IM
Name (Raccordi condotto : M_Gomito rettangolare - Raggio :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | IFC_Descriptions | Group
36 x  0.6 W | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di mandata 2
44 x  0.6 W | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di ritorno 1
55 x  0.6 W | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di ritorno 1
36 x  0.6 W | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di mandata 2
19 x  0.6 W | A-03-FIN | P03 | UTA.03.09 | Meccanico Aria di mandata 7
22 x  0.6 W | A-03-FIN | P03 | UTA.03.09 | Meccanico Aria di ritorno 6
12 x  0.6 W | A-03-FIN | P03 | UTA.03.06 | Meccanico Aria di ritorno 9
12 x  0.6 W | A-03-FIN | P03 | UTA.03.05 | Meccanico Aria di ritorno 14
4 x  0.6 W | A-03-FIN | P03 | UTA.03.04 | Meccanico Aria di mandata 11
12 x  0.6 W | A-03-FIN | P03 | UTA.03.04 | Meccanico Aria di ritorno 15
8 x  0.6 W | A-03-FIN | P03 | UTA.03.01 | Meccanico Aria di mandata 19 (1)
10 x  0.6 W | A-03-FIN | P03 | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
10 x  0.6 W | A-03-FIN | P03 | UTA.03.02. | Meccanico Aria di ritorno 17
15 x  0.6 W | A-03-FIN | P03 | UTA.03.01 | Meccanico Aria di ritorno 22
2 x  0.6 W | A-03-FIN | P03 | UTA.03.03 | Meccanico Aria di mandata 32 (1)
2 x  0.6 W | A-03-FIN | P03 | UTA.03.02. | Meccanico Aria di mandata 34
14 x  0.6 W | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di ritorno 9
14 x  0.6 W | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di ritorno 14
14 x  0.6 W | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di ritorno 15
9 x  0.6 W | A-04-FIN | PC | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
9 x  0.6 W | A-04-FIN | PC | UTA.03.02. | Meccanico Aria di ritorno 17
2 x  0.6 W | A-04-FIN | PC | UTA.03.07 | Meccanico Aria di mandata 2
5 x  0.6 W | A-04-FIN | PC | UTA.03.01 | Meccanico Aria di ritorno 22
2 x  0.6 W | A-04-FIN | PC | UTA.03.09 | Meccanico Aria di mandata 7
3 x  0.6 W | A-04-FIN | PC | UTA.03.08 | Meccanico Aria di ritorno 1
4 x  0.6 W | A-03-FIN | P03 | UTA.03.05 | Meccanico Aria di mandata 8
3 x  0.6 W | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di mandata 8
4 x  0.6 W | A-03-FIN | P03 | UTA.03.06 | Meccanico Aria di mandata 25
3 x  0.6 W | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di mandata 25
4 x  0.6 W | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di mandata 11
 0.6 W | A-04-FIN | PC | UTA.03.08 | Meccanico Aria di scarico 4
3 x  0.6 W | A-04-FIN | PC | UTA.03.09 | Meccanico Aria di scarico 11
5 x  0.6 W | A-04-FIN | PC | UTA.03.08 | Meccanico Aria di mandata 2
 0.6 W | A-04-FIN | PC | UTA.03.07 | Meccanico Aria di scarico 9
2 x  0.6 W | A-04-FIN | PC | UTA.03.02. | Meccanico Aria di mandata 34
2 x  0.6 W | A-04-FIN | PC | UTA.03.03 | Meccanico Aria di mandata 32 (1)
4 x  0.6 W | A-04-FIN | PC | UTA.03.07 | Meccanico Aria di ritorno 1
3 x  0.6 W | A-04-FIN | PC | UTA.03.09 | Meccanico Aria di ritorno 6
 0.6 W | A-03-FIN | PC | UTA.03.07 | Meccanico Aria di ritorno 1
 0.6 W | A-03-FIN | PC | UTA.03.01 | Meccanico Aria di mandata 19 (1)
 0.6 W | A-04-FIN | PC | UTA.03.01 | Meccanico Aria di mandata 19 (1)
2 x  0.6 W | A-03-FIN | P03 |  | Meccanico Aria di ritorno 1
 0.6 W | A-03-FIN | PC |  | Meccanico Aria di mandata 25
 0.6 W | A-03-FIN | PC |  | Meccanico Aria di mandata 8
2 x  0.6 W | A-03-FIN | P03 |  | Meccanico Aria di ritorno 6
 0.6 W | A-04-FIN | PC |  | Meccanico Aria di scarico 9
 0.6 W | A-04-FIN | PC |  | Meccanico Aria di ritorno 6
5 x  0.6 W | A-03-FIN | P03 |  | Meccanico Aria di mandata 2
2 x  0.6 W | A-04-FIN | PC |  | Meccanico Aria di ritorno 1
 0.6 W | A-04-FIN | P03 |  | Meccanico Aria di ritorno 1

# IfcDuctFitting: Raccordi condotto : M_Gomito rettangolare - Raggio : 0.8 W (62)
Type - PredefinedType: CONNECTOR; Classification: 5.4.1 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Curva condotto rettangolare
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Abaco IFCGUID - Famiglia e tipo: M_Gomito rettangolare - Raggio: 0.8 W; WBS_01: DBE; WBS_02: IM
Name (Raccordi condotto : M_Gomito rettangolare - Raggio :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | RIF_EPU | Main Dimensions | IFC_Descriptions | Group
 0.8 W | A-04-FIN | PC | VEN24-12.02.18.01 | sp.21mm | UTA.03.07 | Meccanico Aria di scarico 9
2 x  0.8 W | A-04-FIN | PC | VEN24-12.02.18.01 | sp.21mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
5 x  0.8 W | A-03-FIN | P03 | VEN24-12.02.18.01 | sp.21mm | UTA.03.07 | Meccanico Aria di ritorno 1
5 x  0.8 W | A-03-FIN | P03 | VEN24-12.02.18.01 | sp.21mm | UTA.03.09 | Meccanico Aria di mandata 7
14 x  0.8 W | A-03-FIN | P03 | VEN24-12.02.18.01 | sp.21mm | UTA.03.08 | Meccanico Aria di mandata 2
8 x  0.8 W | A-03-FIN | P03 | VEN24-12.02.18.01 | sp.21mm | UTA.03.07 | Meccanico Aria di mandata 2
15 x  0.8 W | A-03-FIN | P03 | VEN24-12.02.18.01 | sp.21mm | UTA.03.08 | Meccanico Aria di ritorno 1
6 x  0.8 W | A-03-FIN | P03 | VEN24-12.02.18.01 | sp.21mm |  | Meccanico Aria di ritorno 1
 0.8 W | A-03-FIN | P03 | M19.idp.001 | sp.21mm |  | Meccanico Pressurizzazione Filtri 3
2 x  0.8 W | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x150mm |  | Meccanico Aria di ritorno 1
2 x  0.8 W | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x150mm |  | Meccanico Aria di ritorno 1
 0.8 W | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x150mm |  | Meccanico Aria di mandata 2

# IfcDuctFitting: Raccordi condotto : M_Transizione da rettangolare a circolare - Angolo : 45 Degree (59)
In: A-03-FIN
Type - PredefinedType: TRANSITION; Classification: 5.4.1 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Raccordo canale
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: M_Transizione da rettangolare a circolare - Angolo: 45 Degree; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Raccordi condotto : M_Transizione da rettangolare a circolare - Angolo :...) | IFC_Descriptions | Group
18 x  45 Degree | UTA.03.07 | Meccanico Aria di mandata 2
12 x  45 Degree | UTA.03.07 | Meccanico Aria di ritorno 1
12 x  45 Degree | UTA.03.08 | Meccanico Aria di ritorno 1
15 x  45 Degree | UTA.03.08 | Meccanico Aria di mandata 2
 45 Degree | UTA.03.09 | Meccanico Aria di ritorno 6
 45 Degree | UTA.03.09 | Meccanico Aria di mandata 7

# IfcDuctFitting: Raccordi condotto : M_Transizione da rettangolare a circolare - Angolo : 45 gradi (81)
In: A-03-FIN
Type - PredefinedType: TRANSITION; Classification: 5.4.1 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Raccordo canale
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: M_Transizione da rettangolare a circolare - Angolo: 45 gradi; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Raccordi condotto : M_Transizione da rettangolare a circolare - Angolo :...) | RIF_EPU | IFC_Descriptions | Group
19 x  45 gradi | VEN24-12.02.18.01 | UTA.03.07 | Meccanico Aria di ritorno 1
21 x  45 gradi | VEN24-12.02.18.01 | UTA.03.08 | Meccanico Aria di ritorno 1
13 x  45 gradi | VEN24-12.02.18.01 | UTA.03.09 | Meccanico Aria di mandata 7
18 x  45 gradi | VEN24-12.02.18.01 | UTA.03.08 | Meccanico Aria di mandata 2
5 x  45 gradi | VEN24-12.02.18.01 | UTA.03.07 | Meccanico Aria di mandata 2
 45 gradi | VEN24-12.02.18.01 | UTA.03.09 | Meccanico Aria di ritorno 6
2 x  45 gradi | VEN24-12.02.18.01 |  | Meccanico Aria di ritorno 1
 45 gradi | VEN24-12.02.18.01 |  | Meccanico Aria di mandata 2
 45 gradi | M19.idp.001 |  | Meccanico Pressurizzazione Filtri 3

# IfcDuctFitting: Raccordi condotto : M_Transizione da rettangolare a circolare - Angolo : 60 gradi (6)
In: A-03-FIN
Type - PredefinedType: TRANSITION; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Raccordo canale
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: M_Transizione da rettangolare a circolare - Angolo: 60 gradi; WBS_01: DBE; WBS_02: IM; WBS_03: P03
AB_ProperySet - IFC_Descriptions: UTA.03.07
Name (Raccordi condotto : M_Transizione da rettangolare a circolare - Angolo :...) | Group
4 x  60 gradi | Meccanico Aria di mandata 2
2 x  60 gradi | Meccanico Aria di ritorno 1

# IfcDuctFitting: Raccordi condotto : M_Transizione rettangolare - Angolo : 45 gradi (385)
Type - PredefinedType: TRANSITION; Classification: 5.4.1 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Raccordo canale
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: M_Transizione rettangolare - Angolo: 45 gradi; WBS_01: DBE; WBS_02: IM
Name (Raccordi condotto : M_Transizione rettangolare - Angolo :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | IFC_Descriptions | Group
50 x  45 gradi | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di ritorno 1
81 x  45 gradi | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di mandata 2
71 x  45 gradi | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di ritorno 1
78 x  45 gradi | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di mandata 2
7 x  45 gradi | A-03-FIN | P03 | UTA.03.09 | Meccanico Aria di ritorno 6
19 x  45 gradi | A-03-FIN | P03 | UTA.03.09 | Meccanico Aria di mandata 7
4 x  45 gradi | A-03-FIN | P03 | UTA.03.06 | Meccanico Aria di ritorno 9
4 x  45 gradi | A-03-FIN | P03 | UTA.03.05 | Meccanico Aria di ritorno 14
2 x  45 gradi | A-03-FIN | P03 | UTA.03.04 | Meccanico Aria di ritorno 15
2 x  45 gradi | A-03-FIN | P03 | UTA.03.01 | Meccanico Aria di mandata 19 (1)
5 x  45 gradi | A-03-FIN | P03 | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
4 x  45 gradi | A-03-FIN | P03 | UTA.03.02. | Meccanico Aria di ritorno 17
4 x  45 gradi | A-03-FIN | P03 | UTA.03.01 | Meccanico Aria di ritorno 22
3 x  45 gradi | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di mandata 25
3 x  45 gradi | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di mandata 8
3 x  45 gradi | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di mandata 11
 45 gradi | A-04-FIN | PC | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
 45 gradi | A-04-FIN | PC | UTA.03.02. | Meccanico Aria di ritorno 17
 45 gradi | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di ritorno 15
 45 gradi | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di ritorno 14
 45 gradi | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di ritorno 9
2 x  45 gradi | A-04-FIN | PC | UTA.03.08 | Meccanico Aria di mandata 2
2 x  45 gradi | A-04-FIN | PC | UTA.03.02. | Meccanico Aria di mandata 34
2 x  45 gradi | A-04-FIN | PC | UTA.03.03 | Meccanico Aria di mandata 32 (1)
 45 gradi | A-04-FIN | PC | UTA.03.07 | Meccanico Aria di mandata 2
2 x  45 gradi | A-04-FIN | PC | UTA.03.08 | Meccanico Aria di ritorno 1
 45 gradi | A-04-FIN | PC | UTA.03.07 | Meccanico Aria di ritorno 1
 45 gradi | A-04-FIN | PC |  | Meccanico Aria di mandata 32 (1)
 45 gradi | A-04-FIN | PC | UTA.03.01 | Meccanico Aria di mandata 19 (1)
 45 gradi | A-04-FIN | PC |  | Meccanico Aria di mandata 34
2 x  45 gradi | A-04-FIN | PC |  | Meccanico Aria esterna 2
 45 gradi | A-04-FIN | PC |  | Meccanico Aria di ritorno 19 (1)
 45 gradi | A-04-FIN | PC | UTA.03.01 | Meccanico Aria di ritorno 22
 45 gradi | A-04-FIN | PC |  | Meccanico Aria di ritorno 17
 45 gradi | A-04-FIN | PC |  | Meccanico Aria di ritorno 19 (1); Meccanico Aria di scarico 6
 45 gradi | A-04-FIN | PC |  | Meccanico Aria di scarico 6
10 x  45 gradi | A-03-FIN | P03 |  | Meccanico Aria di mandata 2
8 x  45 gradi | A-03-FIN | P03 |  | Meccanico Aria di ritorno 1
 45 gradi | A-03-FIN | P03 |  | Meccanico Aria di ritorno 22
 45 gradi | A-03-FIN | P03 |  | Meccanico Aria di ritorno 6

# IfcDuctFitting: Raccordi condotto : M_Transizione rettangolare - Angolo : 60 gradi (64)
Type - PredefinedType: TRANSITION; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Raccordo canale
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: M_Transizione rettangolare - Angolo: 60 gradi; WBS_01: DBE; WBS_02: IM
Name (Raccordi condotto : M_Transizione rettangolare - Angolo :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | IFC_Descriptions | Group
14 x  60 gradi | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di mandata 2
5 x  60 gradi | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di ritorno 1
14 x  60 gradi | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di mandata 2
3 x  60 gradi | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di ritorno 1
 60 gradi | A-03-FIN | P03 | UTA.03.09 | Meccanico Aria di mandata 7
 60 gradi | A-03-FIN | P03 | UTA.03.04 | Meccanico Aria di ritorno 15
2 x  60 gradi | A-03-FIN | P03 | UTA.03.02. | Meccanico Aria di ritorno 17
2 x  60 gradi | A-03-FIN | P03 | UTA.03.01 | Meccanico Aria di ritorno 22
 60 gradi | A-04-FIN | PC | UTA.03.03 | Meccanico Aria di mandata 32 (1)
 60 gradi | A-04-FIN | PC | UTA.03.02. | Meccanico Aria di mandata 34
 60 gradi | A-04-FIN | PC | UTA.03.01 | Meccanico Aria di mandata 19 (1)
 60 gradi | A-04-FIN | PC | UTA.03.09 | Meccanico Aria di scarico 11
4 x  60 gradi | A-03-FIN | P03 | UTA.03.05 | Meccanico Aria di mandata 8
4 x  60 gradi | A-03-FIN | P03 | UTA.03.06 | Meccanico Aria di mandata 25
4 x  60 gradi | A-03-FIN | P03 | UTA.03.04 | Meccanico Aria di mandata 11
 60 gradi | A-04-FIN | PC | UTA.03.08 | Meccanico Aria di scarico 4
 60 gradi | A-04-FIN | PC | UTA.03.09 | Meccanico Aria di mandata 7
 60 gradi | A-04-FIN | PC | UTA.03.01 | Meccanico Aria di ritorno 22
 60 gradi | A-04-FIN | PC | UTA.03.08 | Meccanico Aria di ritorno 1
 60 gradi | A-04-FIN | PC |  | Meccanico Aria di scarico 9
 60 gradi | A-04-FIN | PC |  | Meccanico Aria di ritorno 6

# IfcDuctFitting: Raccordi condotto : M_Transizione rettangolare - Angolo : 80 gradi (22)
Type - PredefinedType: TRANSITION; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Raccordo canale
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: M_Transizione rettangolare - Angolo: 80 gradi; WBS_01: DBE; WBS_02: IM
Name (Raccordi condotto : M_Transizione rettangolare - Angolo :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | IFC_Descriptions | Group
 80 gradi | A-03-FIN | P03 | UTA.03.04 | Meccanico Aria di ritorno 15
 80 gradi | A-03-FIN | P03 | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
 80 gradi | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di mandata 25
 80 gradi | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di mandata 8
 80 gradi | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di ritorno 14
 80 gradi | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di mandata 11
 80 gradi | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di ritorno 9
 80 gradi | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di ritorno 15
 80 gradi | A-04-FIN | PC | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
 80 gradi | A-04-FIN | PC | UTA.03.02. | Meccanico Aria di ritorno 17
4 x  80 gradi | A-03-FIN | P03 | UTA.03.05 | Meccanico Aria di mandata 8
4 x  80 gradi | A-03-FIN | P03 | UTA.03.06 | Meccanico Aria di mandata 25
4 x  80 gradi | A-03-FIN | P03 | UTA.03.04 | Meccanico Aria di mandata 11

# IfcDuctFitting: Raccordi condotto : P3 - Double Rectangular Curve : default (16)
Type - PredefinedType: CONNECTOR; Material: P3 - Alluminio
Pset Descrizione_Entità - Descrizione_Entità: Curva condotto rettangolare
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: P3 - Double Rectangular Curve: default; WBS_01: DBE; WBS_02: IM
Name (Raccordi condotto : P3 - Double Rectangular Curve :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | IFC_Descriptions | Group
7 x  default | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di mandata 2
2 x  default | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di mandata 2
 default | A-03-FIN | P03 | UTA.03.09 | Meccanico Aria di mandata 7
 default | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di mandata 25
 default | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di mandata 8
 default | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di mandata 11
 default | A-04-FIN | PC | UTA.03.03 | Meccanico Aria di mandata 32 (1)
 default | A-04-FIN | PC | UTA.03.02. | Meccanico Aria di mandata 34
 default | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di ritorno 1

# IfcDuctFitting: Raccordi condotto : P3 - Double Rectangular Curve.0001 : default
In: A-03-FIN
Type - PredefinedType: CONNECTOR; Material: P3 - Alluminio
Pset Descrizione_Entità - Descrizione_Entità: Curva condotto rettangolare
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: P3 - Double Rectangular Curve.0001: default; WBS_01: DBE; WBS_02: IM; WBS_03: P03
AB_ProperySet - IFC_Descriptions: UTA.03.07
Group: Meccanico Aria di mandata 2

# IfcDuctFitting: Raccordi condotto : P3 - Dynamic Reduction with 2 Rectangular Curves : default (4)
Type - PredefinedType: CONNECTOR; Material: P3 - Alluminio
Pset Descrizione_Entità - Descrizione_Entità: Raccordo canale
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: P3 - Dynamic Reduction with 2 Rectangular Curves: default; WBS_01: DBE; WBS_02: IM
Name (Raccordi condotto : P3 - Dynamic Reduction with 2 Rectangular Curves :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | IFC_Descriptions | Group
 default | A-03-FIN | P03 | UTA.03.09 | Meccanico Aria di mandata 7
 default | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di mandata 25
 default | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di mandata 8
 default | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di mandata 11

# IfcDuctFitting: Raccordi condotto : P3 - Reduction with Rectangular Curve : default (59)
In: A-03-FIN
Type - PredefinedType: CONNECTOR; Material: P3 - Alluminio
Pset Descrizione_Entità - Descrizione_Entità: Raccordo canale
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Pset Main Dimensions - Main Dimensions: sp.21mm
Abaco IFCGUID - Famiglia e tipo: P3 - Reduction with Rectangular Curve: default; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Raccordi condotto : P3 - Reduction with Rectangular Curve :...) | IFC_Descriptions | Group
16 x  default | UTA.03.07 | Meccanico Aria di mandata 2
29 x  default | UTA.03.08 | Meccanico Aria di mandata 2
10 x  default | UTA.03.09 | Meccanico Aria di mandata 7
 default | UTA.03.01 | Meccanico Aria di mandata 19 (1)
 default | UTA.03.09 | Meccanico Aria di ritorno 6
 default | UTA.03.08 | Meccanico Aria di ritorno 1
 default |  | Meccanico Aria di mandata 2

# IfcDuctFitting: Raccordi tubazione : M_Acciaio Nero _ Calotta - Saldato : Acciaio nero (28)
Type - PredefinedType: OBSTRUCTION; Classification: 5.4.1 (Default Classification); Material: Acciaio nero, carbonio
Pset Descrizione_Entità - Descrizione_Entità: Calotta di chiusura
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Tubazione - Acciaio Nero
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.40.01-02
Abaco IFCGUID - Famiglia e tipo: M_Acciaio Nero _ Calotta - Saldato: Acciaio nero; WBS_01: DBE; WBS_02: IM
Name (Raccordi tubazione : M_Acciaio Nero _ Calotta - Saldato :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Group
3 x  Acciaio nero | A-04-FIN | PC | REF 2
3 x  Acciaio nero | A-04-FIN | PC | REF 13
3 x  Acciaio nero | A-04-FIN | PC | RIS 7
3 x  Acciaio nero | A-04-FIN | PC | RIS 10
2 x  Acciaio nero | A-I1-FIN | I00 | REF 9
4 x  Acciaio nero | A-I1-FIN | I00 | Mandata Post 2 (1) (1)
6 x  Acciaio nero | A-I1-FIN | I00 | RIS 10
2 x  Acciaio nero | A-TR-FIN | I00 | REF 2
2 x  Acciaio nero | A-I1-FIN | I00 | RIS 7

# IfcDuctSegment: Attrezzatura meccanica : Plenum : Plenum sala operatoria (6)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Plenum sala operatoria
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Plenum per sala operatoria
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Abaco IFCGUID - Famiglia e tipo: Plenum: Plenum sala operatoria; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Attrezzatura meccanica : Plenum :...) | Group
 Plenum sala operatoria | Meccanico Aria di mandata 5; Meccanico Aria di mandata 25
 Plenum sala operatoria | Meccanico Aria di mandata 4; Meccanico Aria di mandata 25
 Plenum sala operatoria | Meccanico Aria di mandata 15; Meccanico Aria di mandata 11
 Plenum sala operatoria | Meccanico Aria di mandata 18; Meccanico Aria di mandata 11
 Plenum sala operatoria | Meccanico Aria di mandata 13; Meccanico Aria di mandata 8
 Plenum sala operatoria | Meccanico Aria di mandata 14; Meccanico Aria di mandata 8

# IfcDuctSegment: Condotto : Condotto circolare : Giunti/Raggio stretto (5)
In: A-03-FIN
Type - PredefinedType: RIGIDSEGMENT
Classification: 5.4.1 (Default Classification)
Pset Descrizione_Entità - Descrizione_Entità: Condotto Aeraulico Circolare
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Condotto circolare
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Abaco IFCGUID - Famiglia e tipo: Condotto circolare: Giunti/Raggio stretto; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Condotto : Condotto circolare :...) | RIF_EPU | Main Dimensions | Group
 Giunti/Raggio stretto | VEN24-12.02.18.01 | Ø150mm | Meccanico Aria di ritorno 1 | AB_ProperySet - IFC_Descriptions: UTA.03.07
 Giunti/Raggio stretto | M19.idp.001 | Ø315mm | Meccanico Pressurizzazione Filtri 1
 Giunti/Raggio stretto | M19.idp.001 | Ø315mm | Meccanico Pressurizzazione Filtri 2
 Giunti/Raggio stretto | M19.idp.001 | Ø315mm | Meccanico Estrazione cucina 3; Meccanico Pressurizzazione Filtri 3
 Giunti/Raggio stretto | M19.idp.001 | Ø355mm | Meccanico Pressurizzazione Filtri 4

# IfcDuctSegment: Condotto : Condotto rettangolare : Raggio gomiti / Giunti (6)
In: A-04-FIN
Type - PredefinedType: RIGIDSEGMENT
Classification: 5.1.4 (Default Classification)
Pset Descrizione_Entità - Descrizione_Entità: Condotto aeraulico Rettangolare
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: PC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Abaco IFCGUID - Famiglia e tipo: Condotto rettangolare: Raggio gomiti / Giunti; WBS_01: DBE; WBS_02: IM; WBS_03: PC
Name (Condotto : Condotto rettangolare :...) | Main Dimensions | IFC_Descriptions | Group
 Raggio gomiti / Giunti | 800x600mm | UTA.03.06 | Meccanico Aria di mandata 25
 Raggio gomiti / Giunti | 600x400mm | UTA.03.06 | Meccanico Aria di mandata 25
 Raggio gomiti / Giunti | 800x600mm | UTA.03.05 | Meccanico Aria di mandata 8
 Raggio gomiti / Giunti | 600x400mm | UTA.03.05 | Meccanico Aria di mandata 8
 Raggio gomiti / Giunti | 800x600mm | UTA.03.04 | Meccanico Aria di mandata 11
 Raggio gomiti / Giunti | 600x400mm | UTA.03.04 | Meccanico Aria di mandata 11

# IfcDuctSegment: Condotto flessibile : Condotto flessibile circolare : Flessibile - Circolare (143)
In: A-03-FIN
Type - PredefinedType: FLEXIBLESEGMENT
Classification: 5.4.1 (Default Classification)
Pset Descrizione_Entità - Descrizione_Entità: Condotto Flessibile Circolare
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canale flessibile spiralato
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: VEN24-12.02.15.02
Abaco IFCGUID - Famiglia e tipo: Condotto flessibile circolare: Flessibile - Circolare; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Condotto flessibile : Condotto flessibile circolare :...) | IFC_Descriptions | Group
27 x  Flessibile - Circolare | UTA.03.07 | Meccanico Aria di mandata 2
35 x  Flessibile - Circolare | UTA.03.07 | Meccanico Aria di ritorno 1
31 x  Flessibile - Circolare | UTA.03.08 | Meccanico Aria di ritorno 1
32 x  Flessibile - Circolare | UTA.03.08 | Meccanico Aria di mandata 2
14 x  Flessibile - Circolare | UTA.03.09 | Meccanico Aria di mandata 7
2 x  Flessibile - Circolare | UTA.03.09 | Meccanico Aria di ritorno 6
 Flessibile - Circolare |  | Meccanico Aria di mandata 2
 Flessibile - Circolare |  | Meccanico Aria di ritorno 1

# IfcFan: Attrezzatura meccanica : Ventilatore Filtro Fumo : Master Black Compact 3.2 (3)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Ventilatore Filtro fumo
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Ventilatore Filtro fumo 3.2
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M19.idp.001
Abaco IFCGUID - Famiglia e tipo: Ventilatore Filtro Fumo: Master Black Compact 3.2; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Attrezzatura meccanica : Ventilatore Filtro Fumo :...) | Group
 Master Black Compact 3.2 | Meccanico Pressurizzazione Filtri 1
 Master Black Compact 3.2 | Meccanico Pressurizzazione Filtri 2
 Master Black Compact 3.2 | Meccanico Estrazione cucina 3

# IfcFan: Attrezzatura meccanica : Ventilatore Filtro Fumo : Master Black Compact 4.2
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Ventilatore Filtro fumo
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Ventilatore Filtro fumo 4.2
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M19.idp.001
Abaco IFCGUID - Famiglia e tipo: Ventilatore Filtro Fumo: Master Black Compact 4.2; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Meccanico Pressurizzazione Filtri 4

# IfcFilter: Accessori per condotti : SC_HEPA filter : SC_HEPA filter (150)
In: A-03-FIN
Type - PredefinedType: USERDEFINED; Material: SC_Air Filter_OT
Pset Descrizione_Entità - Descrizione_Entità: Filtro HEPA
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Filtro H14 per plafone immissione aria
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M16.lso.001-003
Abaco IFCGUID - Famiglia e tipo: SC_HEPA filter: SC_HEPA filter; WBS_01: DBE; WBS_02: IM; WBS_03: P03

# IfcHeatExchanger: Attrezzatura meccanica : Scambiatore a Piastre : Scambiatore a Piastre (2)
In: A-I1-FIN
Type - PredefinedType: PLATE; Material: Alfa Laval - Stainless Steel, Alfa Laval - Blue, Alfa Laval - Red
Pset Descrizione_Entità - Descrizione_Entità: Scambiatore di calore
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Pt 500KW
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 025059d
Abaco IFCGUID - Famiglia e tipo: Scambiatore a Piastre: Scambiatore a Piastre; WBS_01: DBE; WBS_02: IM; WBS_03: I00
Group: RIS 10; RIS 7; RIS 6; RIS 8

# IfcHumidifier: Attrezzatura meccanica : Umidificatore : Umidificatore (9)
In: A-04-FIN
Type - PredefinedType: STEAMINJECTION; Material: Plastic - Carel - Black, Plastic - Carel - Gray, Copper - Carel, Stainless Steel - Carel
Classification: D3090200 Uniformat (Uniformat)
Pset Descrizione_Entità - Descrizione_Entità: Umidificatore a vapore
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: PC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: A Vapore
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: M19.idu.101-105
Abaco IFCGUID - Famiglia e tipo: Umidificatore: Umidificatore; WBS_01: DBE; WBS_02: IM; WBS_03: PC

# IfcMechanicalFastener: Raccordi tubazione : x_Fasteners - Bolts - DIN 931 : x_Fasteners - Bolts - DIN 931 (128)
In: A-I1-FIN
Type - PredefinedType: BOLT; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Bolts
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Bullone
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.40.01-02
Abaco IFCGUID - Famiglia e tipo: x_Fasteners - Bolts - DIN 931: x_Fasteners - Bolts - DIN 931; WBS_01: DBE; WBS_02: IM; WBS_03: I00

# IfcMechanicalFastener: Raccordi tubazione : x_Fasteners - Nuts - DIN 934 : x_Fasteners - Nuts - DIN 934 (128)
In: A-I1-FIN
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Nuts
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.40.01-02
Abaco IFCGUID - Famiglia e tipo: x_Fasteners - Nuts - DIN 934: x_Fasteners - Nuts - DIN 934; WBS_01: DBE; WBS_02: IM; WBS_03: I00
Name (Raccordi tubazione : x_Fasteners - Nuts - DIN 934 :...) | Main Mechanical Data
 x_Fasteners - Nuts - DIN 934 | Bullone
127 x  x_Fasteners - Nuts - DIN 934 | Dado

# IfcPipeFitting: Attrezzatura meccanica : Separatore idraulico : Separatore idraulico
In: A-I1-FIN
Type - PredefinedType: USERDEFINED; Material: Metal - Caleffi - Stainless Steel, Plastic - Caleffi - Yellow, Metal - Caleffi - Brass, Plastic - Caleffi - Black, Paint - Caleffi - Green
Classification: D3040 Uniformat (Uniformat); Group: REF 13; REF 9; REF 8; REF 14
Pset Descrizione_Entità - Descrizione_Entità: Flanged Hydraulic Separator
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: DN 200 120m³/h
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 025160a
Abaco IFCGUID - Famiglia e tipo: Separatore idraulico: Separatore idraulico; WBS_01: DBE; WBS_02: IM; WBS_03: I00

# IfcPipeFitting: Attrezzatura meccanica : Sistema di dosaggio : Sistema di dosaggio
In: A-TR-FIN
Type - PredefinedType: USERDEFINED; Classification: 5.1.4 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Sistemi di dosaggio
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Sistema di dosaggio
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-11.02.28.01
Abaco IFCGUID - Famiglia e tipo: Sistema di dosaggio: Sistema di dosaggio; WBS_01: DBE; WBS_02: IM; WBS_03: I00

# IfcPipeFitting: Raccordi tubazione : M_Acciaio Nero _ Gomito - Saldato : Acciaio nero (276)
Type - PredefinedType: CONNECTOR; Classification: 5.4.1 (Default Classification); Material: Acciaio nero, carbonio
Pset Descrizione_Entità - Descrizione_Entità: Curva tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Tubazione - Acciaio Nero
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.40.01-02
Abaco IFCGUID - Famiglia e tipo: M_Acciaio Nero _ Gomito - Saldato: Acciaio nero; WBS_01: DBE; WBS_02: IM
Name (Raccordi tubazione : M_Acciaio Nero _ Gomito - Saldato :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Group
 Acciaio nero | A-03-FIN | PC | RIS 10
37 x  Acciaio nero | A-04-FIN | PC | RIS 10
2 x  Acciaio nero | A-03-FIN | PC | RIS 7
 Acciaio nero | A-03-FIN | P03 | Mandata Post 2 (1) (1)
 Acciaio nero | A-03-FIN | P03 | Ritorno Post 1 (1) (1)
 Acciaio nero | A-03-FIN | PC | REF 13
36 x  Acciaio nero | A-04-FIN | PC | REF 13
52 x  Acciaio nero | A-04-FIN | PC | RIS 7
29 x  Acciaio nero | A-04-FIN | PC | REF 2
5 x  Acciaio nero | A-01-FIN | P01 | RIS 7
2 x  Acciaio nero | A-01-FIN | P00 | RIS 7
 Acciaio nero | A-03-FIN | P01 | REF 2
2 x  Acciaio nero | A-03-FIN | PC | REF 2
 Acciaio nero | A-03-FIN | P01 | REF 13
 Acciaio nero | A-03-FIN | P01 | RIS 10
5 x  Acciaio nero | A-01-FIN | P01 | REF 13
5 x  Acciaio nero | A-01-FIN | P01 | RIS 10
 Acciaio nero | A-03-FIN | P01 | RIS 7
4 x  Acciaio nero | A-01-FIN | P01 | REF 2
 Acciaio nero | A-01-FIN | P00 | REF 2
 Acciaio nero | A-01-FIN | P00 | RIS 10
 Acciaio nero | A-01-FIN | P00 | REF 13
 Acciaio nero | A-01-FIN | I00 | RIS 7
2 x  Acciaio nero | A-03-FIN | P01 | Ritorno Post 1 (1) (1)
4 x  Acciaio nero | A-01-FIN | P01 | Ritorno Post 1 (1) (1)
5 x  Acciaio nero | A-01-FIN | P01 | Mandata Post 2 (1) (1)
 Acciaio nero | A-03-FIN | P01 | Mandata Post 2 (1) (1)
2 x  Acciaio nero | A-01-FIN | P00 | Ritorno Post 1 (1) (1)
2 x  Acciaio nero | A-01-FIN | P00 | Mandata Post 2 (1) (1)
 Acciaio nero | A-01-FIN | I00 | Ritorno Post 1 (1) (1)
 Acciaio nero | A-01-FIN | I00 | Mandata Post 2 (1) (1)
3 x  Acciaio nero | A-TR-FIN | P00 | REF 13
3 x  Acciaio nero | A-TR-FIN | P00 | REF 2
3 x  Acciaio nero | A-TR-FIN | P00 | RIS 10
2 x  Acciaio nero | A-TR-FIN | P00 | RIS 7
2 x  Acciaio nero | A-TR-FIN | P00 | Ritorno Post 1 (1) (1)
2 x  Acciaio nero | A-TR-FIN | P00 | Mandata Post 2 (1) (1)
3 x  Acciaio nero | A-I1-FIN | I00 | Mandata Post 2 (1) (1)
3 x  Acciaio nero | A-I1-FIN | I00 | Ritorno Post 1 (1) (1)
6 x  Acciaio nero | A-I1-FIN | I00 | RIS 10
12 x  Acciaio nero | A-I1-FIN | I00 | RIS 7
2 x  Acciaio nero | A-I1-FIN | I00 | REF 2
8 x  Acciaio nero | A-I1-FIN | I00 | REF 13
2 x  Acciaio nero | A-I1-FIN | I00 | REF 9
5 x  Acciaio nero | A-I1-FIN | I00 | RIS 6
5 x  Acciaio nero | A-I1-FIN | I00 | RIS 8
3 x  Acciaio nero | A-I1-FIN | I00 | REF 8
3 x  Acciaio nero | A-I1-FIN | I00 | REF 14

# IfcPipeFitting: Raccordi tubazione : M_Acciaio Nero _ Tee - Saldato : Acciaio nero (92)
Type - PredefinedType: JUNCTION; Classification: 5.4.1 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Raccordo a T tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Tubazione - Acciaio Nero
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.40.01-02
Abaco IFCGUID - Famiglia e tipo: M_Acciaio Nero _ Tee - Saldato: Acciaio nero; WBS_01: DBE; WBS_02: IM
Name (Raccordi tubazione : M_Acciaio Nero _ Tee - Saldato :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Group
11 x  Acciaio nero | A-04-FIN | PC | REF 13
11 x  Acciaio nero | A-04-FIN | PC | REF 2
18 x  Acciaio nero | A-04-FIN | PC | RIS 10
18 x  Acciaio nero | A-04-FIN | PC | RIS 7
6 x  Acciaio nero | A-I1-FIN | I00 | Mandata Post 2 (1) (1)
10 x  Acciaio nero | A-I1-FIN | I00 | RIS 10
3 x  Acciaio nero | A-I1-FIN | I00 | REF 9
3 x  Acciaio nero | A-I1-FIN | I00 | REF 2
4 x  Acciaio nero | A-I1-FIN | I00 | RIS 7
 Acciaio nero | A-I1-FIN | I00 | RIS 7; POST 1
 Acciaio nero | A-I1-FIN | I00 | RIS 6
 Acciaio nero | A-I1-FIN | I00 | RIS 8
 Acciaio nero | A-I1-FIN | I00 | RIS 8; Altro 2; Altro 6
 Acciaio nero | A-I1-FIN | I00 | RIS 6; Altro 3; Altro 7
 Acciaio nero | A-I1-FIN | I00 | Altro 5; REF 14; Altro 1
 Acciaio nero | A-I1-FIN | I00 | Altro 4; REF 8; Altro 8
 Acciaio nero | A-I1-FIN | I00 | REF 13

# IfcPipeFitting: Raccordi tubazione : M_Acciaio Nero _ Transizione - Saldato : Acciaio nero (31)
Type - PredefinedType: TRANSITION; Classification: 5.4.1 (Default Classification); Material: Acciaio nero, carbonio
Pset Descrizione_Entità - Descrizione_Entità: Raccordo per cambio sezione
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Tubazione - Acciaio Nero
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.40.01-02
Abaco IFCGUID - Famiglia e tipo: M_Acciaio Nero _ Transizione - Saldato: Acciaio nero; WBS_01: DBE; WBS_02: IM
Name (Raccordi tubazione : M_Acciaio Nero _ Transizione - Saldato :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Group
2 x  Acciaio nero | A-I1-FIN | I00 | REF 2
3 x  Acciaio nero | A-I1-FIN | I00 | REF 9
 Acciaio nero | A-I1-FIN | I00 | REF 13
 Acciaio nero | A-I1-FIN | I00 | REF 14
 Acciaio nero | A-I1-FIN | I00 | REF 8
4 x  Acciaio nero | A-04-FIN | PC | RIS 7
4 x  Acciaio nero | A-04-FIN | PC | RIS 10
6 x  Acciaio nero | A-04-FIN | PC | REF 2
5 x  Acciaio nero | A-04-FIN | PC | REF 13
4 x  Acciaio nero | A-I1-FIN | I00 | RIS 10

# IfcPipeFitting: Raccordi tubazione : PIF_Aquasystem elbow_GF : DN12 - DN100 Elbow(90°) PN20, DN12 - DN65 Elbow(45°) PN20 (302)
In: A-03-FIN
Type - Description: Aquasystem PP-R Elbow; PredefinedType: BEND; Classification: 5.1.4 (Default Classification); Material: Green for Polypropylene (PP-RCT)
Pset Descrizione_Entità - Descrizione_Entità: Curva tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Curva di raccordo - Polipropilene
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 025095a-b / 025096a-c / 015015a
Abaco IFCGUID - Famiglia e tipo: PIF_Aquasystem elbow_GF: DN12 - DN100 Elbow(90°) PN20, DN12 - DN65 Elbow(45°) PN20; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Raccordi tubazione : PIF_Aquasystem elbow_GF :...) | Group
169 x  DN12 - DN100 Elbow(90°) PN20, DN12 - DN65 Elbow(45°) PN20 | Ritorno Post 1 (1) (1)
133 x  DN12 - DN100 Elbow(90°) PN20, DN12 - DN65 Elbow(45°) PN20 | Mandata Post 2 (1) (1)

# IfcPipeFitting: Raccordi tubazione : PIF_Aquasystem end cap_GF : DN12 - DN100, PN20 (2)
In: A-03-FIN
Type - Description: Aquasystem PP-R End cap; PredefinedType: USERDEFINED; Classification: 5.4.1 (Default Classification); Material: Green for Polypropylene (PP-RCT)
Pset Descrizione_Entità - Descrizione_Entità: Calotta di chiusura
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Tappo - Polipropilene
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 025095a-b / 025096a-c / 015015a
Abaco IFCGUID - Famiglia e tipo: PIF_Aquasystem end cap_GF: DN12 - DN100, PN20; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Raccordi tubazione : PIF_Aquasystem end cap_GF :...) | Group
 DN12 - DN100, PN20 | Ritorno Post 1 (1) (1)
 DN12 - DN100, PN20 | Mandata Post 2 (1) (1)

# IfcPipeFitting: Raccordi tubazione : PIF_Aquasystem reducer_GF : DN12 - DN100, PN20 (301)
In: A-03-FIN
Type - Description: Aquasystem PP-R Reducer; PredefinedType: CONNECTOR; Classification: 5.1.4 (Default Classification); Material: Green for Polypropylene (PP-RCT)
Pset Descrizione_Entità - Descrizione_Entità: Riduttore tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Raccordo - Polipropilene
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 025095a-b / 025096a-c / 015015a
Abaco IFCGUID - Famiglia e tipo: PIF_Aquasystem reducer_GF: DN12 - DN100, PN20; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Raccordi tubazione : PIF_Aquasystem reducer_GF :...) | Group
162 x  DN12 - DN100, PN20 | Ritorno Post 1 (1) (1)
139 x  DN12 - DN100, PN20 | Mandata Post 2 (1) (1)

# IfcPipeFitting: Raccordi tubazione : PIF_Aquasystem socket_GF : DN12 - DN100, PN20 (2)
In: A-03-FIN
Type - Description: Aquasystem PP-R Socket; PredefinedType: CONNECTOR; Material: Green for Polypropylene (PP-RCT)
Pset Descrizione_Entità - Descrizione_Entità: Raccordo tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Raccordo - Polipropilene
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 025095a-b / 025096a-c / 015015a
Abaco IFCGUID - Famiglia e tipo: PIF_Aquasystem socket_GF: DN12 - DN100, PN20; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Raccordi tubazione : PIF_Aquasystem socket_GF :...) | Group
 DN12 - DN100, PN20 | Mandata Post 2 (1) (1)
 DN12 - DN100, PN20 | Ritorno Post 1 (1) (1)

# IfcPipeFitting: Raccordi tubazione : PIF_Aquasystem tee_GF : DN12 - DN100 Tee(eq) PN20, DN12 - DN50 Tee(red) PN20 (94)
In: A-03-FIN
Type - Description: Aquasystem PP-R Tee; PredefinedType: JUNCTION; Classification: 5.1.4 (Default Classification); Material: Green for Polypropylene (PP-RCT)
Pset Descrizione_Entità - Descrizione_Entità: Raccordo a T tubazione
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Raccordo a T - Polipropilene
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 025095a-b / 025096a-c / 015015a
Abaco IFCGUID - Famiglia e tipo: PIF_Aquasystem tee_GF: DN12 - DN100 Tee(eq) PN20, DN12 - DN50 Tee(red) PN20; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Raccordi tubazione : PIF_Aquasystem tee_GF :...) | Group
28 x  DN12 - DN100 Tee(eq) PN20, DN12 - DN50 Tee(red) PN20 | Mandata Post 2 (1) (1); Ritorno Post 1 (1) (1)
33 x  DN12 - DN100 Tee(eq) PN20, DN12 - DN50 Tee(red) PN20 | Ritorno Post 1 (1) (1)
33 x  DN12 - DN100 Tee(eq) PN20, DN12 - DN50 Tee(red) PN20 | Mandata Post 2 (1) (1)

# IfcPipeFitting: Raccordi tubazione : x_Pipe Fitting - Flange - ISO 7005-2 : x_Pipe Fitting - Flange - ISO 7005-2 (32)
In: A-I1-FIN
Type - PredefinedType: TRANSITION; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Flangia
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Flangia
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.40.01-02
Abaco IFCGUID - Famiglia e tipo: x_Pipe Fitting - Flange - ISO 7005-2: x_Pipe Fitting - Flange - ISO 7005-2; WBS_01: DBE; WBS_02: IM; WBS_03: I00

# IfcPipeSegment: Accessori per tubazioni : Giunto elastico in gomma : DN050 (4)
In: A-I1-FIN
Type - PredefinedType: FLEXIBLESEGMENT; Material: EPDM
Pset Descrizione_Entità - Descrizione_Entità: Giunto anti vibrante
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Giunto_Antivibrante
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: VEN24-12.04.16.05-08-10
Abaco IFCGUID - Famiglia e tipo: Giunto elastico in gomma: DN050; WBS_01: DBE; WBS_02: IM; WBS_03: I00
Group: Mandata Post 2 (1) (1)

# IfcPipeSegment: Accessori per tubazioni : Giunto_Antivibrante : Giunto_Antivibrante (8)
In: A-I1-FIN
Type - PredefinedType: FLEXIBLESEGMENT; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Giunto anti vibrante
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Giunto_Antivibrante
Pset RIF_Crono - RIF_Crono: M8_S31_G20
Pset RIF_EPU - RIF_EPU: VEN24-12.04.16.05-08-10
Abaco IFCGUID - Famiglia e tipo: Giunto_Antivibrante: Giunto_Antivibrante; WBS_01: DBE; WBS_02: IM; WBS_03: I00
Name (Accessori per tubazioni : Giunto_Antivibrante :...) | Group
4 x  Giunto_Antivibrante | RIS 10
2 x  Giunto_Antivibrante | REF 9
2 x  Giunto_Antivibrante | REF 2

# IfcPipeSegment: Tubazioni : Tubazione : Acciaio nero - DN10-150 - T (508)
Type - PredefinedType: RIGIDSEGMENT
Classification: 5.1.4 (Default Classification)
Pset Descrizione_Entità - Descrizione_Entità: Tubazione in acciaio nero
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Tubazione - Acciaio Nero
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Abaco IFCGUID - Famiglia e tipo: Tubazione: Acciaio nero - DN10-150 - T; WBS_01: DBE; WBS_02: IM
Name (Tubazioni : Tubazione :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | RIF_EPU | Group
 Acciaio nero - DN10-150 - T | A-04-FIN | P03 | VEN24-12.04.40.01-02 | REF 13
 Acciaio nero - DN10-150 - T | A-04-FIN | P03 | VEN24-12.04.40.01-02 | REF 2
77 x  Acciaio nero - DN10-150 - T | A-04-FIN | PC | VEN24-12.04.40.01-02 | RIS 10
93 x  Acciaio nero - DN10-150 - T | A-04-FIN | PC | VEN24-12.04.40.01-02 | RIS 7
2 x  Acciaio nero - DN10-150 - T | A-03-FIN | P03 | VEN24-12.04.40.01-02 | Ritorno Post 1 (1) (1)
2 x  Acciaio nero - DN10-150 - T | A-03-FIN | P03 | VEN24-12.04.40.01-02 | Mandata Post 2 (1) (1)
57 x  Acciaio nero - DN10-150 - T | A-04-FIN | PC | VEN24-12.04.40.01-02 | REF 2
62 x  Acciaio nero - DN10-150 - T | A-04-FIN | PC | VEN24-12.04.40.01-02 | REF 13
6 x  Acciaio nero - DN10-150 - T | A-01-FIN | P01 | VEN24-12.04.40.01-02 | RIS 10
6 x  Acciaio nero - DN10-150 - T | A-01-FIN | P01 | VEN24-12.04.40.01-02 | RIS 7
5 x  Acciaio nero - DN10-150 - T | A-01-FIN | P01 | VEN24-12.04.40.01-02 | REF 13
23 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | RIS 7
4 x  Acciaio nero - DN10-150 - T | A-01-FIN | P01 | VEN24-12.04.40.01-02 | REF 2
 Acciaio nero - DN10-150 - T | A-01-FIN | P00 | VEN24-12.04.40.01-02 | REF 13
 Acciaio nero - DN10-150 - T | A-01-FIN | P00 | VEN24-12.04.40.01-02 | REF 2
13 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | REF 2
35 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | RIS 10
11 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | REF 13
13 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | REF 9
6 x  Acciaio nero - DN10-150 - T | A-01-FIN | P01 | VEN24-12.04.40.01-02 | Mandata Post 2 (1) (1)
 Acciaio nero - DN10-150 - T | A-03-FIN | P01 | 025096b | Ritorno Post 1 (1) (1)
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Altro 2
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Altro 3
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Altro 4
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Altro 5
26 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Mandata Post 2 (1) (1)
5 x  Acciaio nero - DN10-150 - T | A-01-FIN | P01 | VEN24-12.04.40.01-02 | Ritorno Post 1 (1) (1)
5 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Ritorno Post 1 (1) (1)
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Mandata Post 2 (1) (1); RIS 10
3 x  Acciaio nero - DN10-150 - T | A-TR-FIN | P00 | VEN24-12.04.40.01-02 | REF 13
3 x  Acciaio nero - DN10-150 - T | A-TR-FIN | P00 | VEN24-12.04.40.01-02 | REF 2
3 x  Acciaio nero - DN10-150 - T | A-TR-FIN | P00 | VEN24-12.04.40.01-02 | RIS 10
3 x  Acciaio nero - DN10-150 - T | A-TR-FIN | P00 | VEN24-12.04.40.01-02 | RIS 7
3 x  Acciaio nero - DN10-150 - T | A-TR-FIN | P00 | VEN24-12.04.40.01-02 | Ritorno Post 1 (1) (1)
3 x  Acciaio nero - DN10-150 - T | A-TR-FIN | P00 | VEN24-12.04.40.01-02 | Mandata Post 2 (1) (1)
8 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | RIS 6
8 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | RIS 8
4 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | REF 8
4 x  Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | REF 14
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Altro 6
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Altro 7
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Altro 1
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | Altro 8
 Acciaio nero - DN10-150 - T | A-I1-FIN | I00 | VEN24-12.04.40.01-02 | POST 1

# IfcPipeSegment: Tubazioni : Tubazione : Aquasystem PP-R, PN10/SDR11 (636)
In: A-03-FIN
Type - Description: Aqusystem PP-R; PredefinedType: RIGIDSEGMENT
Classification: 5.1.4 (Default Classification)
Pset Descrizione_Entità - Descrizione_Entità: Tubazione in PP-R
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Tubazione - Polipropilene
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Abaco IFCGUID - Famiglia e tipo: Tubazione: Aquasystem PP-R, PN10/SDR11; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Tubazioni : Tubazione :...) | RIF_EPU | Group
22 x  Aquasystem PP-R, PN10/SDR11 | 025096c | Ritorno Post 1 (1) (1)
22 x  Aquasystem PP-R, PN10/SDR11 | 025096c | Mandata Post 2 (1) (1)
269 x  Aquasystem PP-R, PN10/SDR11 | 025095a-b | Ritorno Post 1 (1) (1)
239 x  Aquasystem PP-R, PN10/SDR11 | 025095a-b | Mandata Post 2 (1) (1)
20 x  Aquasystem PP-R, PN10/SDR11 | 015015a | Ritorno Post 1 (1) (1)
23 x  Aquasystem PP-R, PN10/SDR11 | 025096a | Ritorno Post 1 (1) (1)
17 x  Aquasystem PP-R, PN10/SDR11 | 025096a | Mandata Post 2 (1) (1)
20 x  Aquasystem PP-R, PN10/SDR11 | 015015a | Mandata Post 2 (1) (1)
2 x  Aquasystem PP-R, PN10/SDR11 | 025096b | Ritorno Post 1 (1) (1)
2 x  Aquasystem PP-R, PN10/SDR11 | 025096b | Mandata Post 2 (1) (1)

# IfcPump: Attrezzatura meccanica : Pompa in linea - Caldo : 4.6 LPS - 2.9 max (4)
In: A-I1-FIN
Type - PredefinedType: CIRCULATOR; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Pompa circuiti caldo
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Abaco IFCGUID - Famiglia e tipo: Pompa in linea - Caldo: 4.6 LPS - 2.9 max; WBS_01: DBE; WBS_02: IM; WBS_03: I00
Name (Attrezzatura meccanica : Pompa in linea - Caldo :...) | Main Mechanical Data | RIF_EPU | Group
2 x  4.6 LPS - 2.9 max | Elettropompa circito acqua calda Post UTA Q 8m³/h H 18m - P.C.POST.001a - P.C.POST.001b | VEN24-12.04.11.23 | Mandata Post 2 (1) (1)
2 x  4.6 LPS - 2.9 max | Elettropompa circito acqua calda Pre UTA Q 40m³/h H 18m - P.C.UTA.001a - P.C.UTA.001b | VEN24-12.04.11.30 | RIS 10

# IfcPump: Attrezzatura meccanica : Pompa in linea - Freddo : TPE 100-200/4_50_99114257 (2)
In: A-I1-FIN
Type - PredefinedType: CIRCULATOR; Material: Grundfos - Light Black
Pset Descrizione_Entità - Descrizione_Entità: Pompe primario freddo
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Elettropompa circito acqua refrigerata Q 120m³/h H 15m - P.F.UTA001a - P.F.UTA001b
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.11.38
Abaco IFCGUID - Famiglia e tipo: Pompa in linea - Freddo: TPE 100-200/4_50_99114257; WBS_01: DBE; WBS_02: IM; WBS_03: I00
Group: REF 2; REF 9

# IfcSpaceHeater: Attrezzatura meccanica : Radiatore : Radiatore (5)
In: A-03-FIN
Type - PredefinedType: RADIATOR; Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Radiatore
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Radiatore a parete
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.48.02
Abaco IFCGUID - Famiglia e tipo: Radiatore: Radiatore; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Group: Mandata Post 2 (1) (1); Ritorno Post 1 (1) (1)

# IfcTank: Attrezzatura meccanica : Vaso di espansione : Vaso di espansione 100L
In: A-I1-FIN
Type - PredefinedType: EXPANSION; Material: Steel - Taco - Carbon - Red Oxide
Classification: D3040 Uniformat (Uniformat); Group: REF 13
Pset Descrizione_Entità - Descrizione_Entità: Vaso di espansione 100L
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Vaso di espansione 100 litri
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.59.09
Abaco IFCGUID - Famiglia e tipo: Vaso di espansione: Vaso di espansione 100L; WBS_01: DBE; WBS_02: IM; WBS_03: I00

# IfcTank: Attrezzatura meccanica : Vaso di espansione : Vaso di espansione 200L
In: A-I1-FIN
Type - PredefinedType: EXPANSION; Material: Steel - Taco - Carbon - Red Oxide
Classification: D3040 Uniformat (Uniformat); Group: RIS 7
Pset Descrizione_Entità - Descrizione_Entità: Vaso di espansione 200L
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: I00
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Vaso di espansione 200 litri
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.04.59.11
Abaco IFCGUID - Famiglia e tipo: Vaso di espansione: Vaso di espansione 200L; WBS_01: DBE; WBS_02: IM; WBS_03: I00

# IfcUnitaryEquipment: Attrezzatura meccanica : Cassetta a 4 vie : taglia 25 (2)
In: A-03-FIN
Type - PredefinedType: SPLITSYSTEM; Material: RSen_x_rgb 188 188 190 T00 gray_gen, <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Cassetta vrv a soffitto
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Cassetta 4 vie per sistema espansione diretta
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 035131b
Abaco IFCGUID - Famiglia e tipo: Cassetta a 4 vie: taglia 25; WBS_01: DBE; WBS_02: IM; WBS_03: P03
Name (Attrezzatura meccanica : Cassetta a 4 vie :...)
 taglia 25 | Group: SR 2; SR 1
 taglia 25

# IfcUnitaryEquipment: Attrezzatura meccanica : RSen_55_ME_FB_SOg - fxaq25auv1b - SH_daikin_tbq : standard
In: A-03-FIN
Type - PredefinedType: SPLITSYSTEM; Material: RSen_x_rgb 055 053 053 T00 gray_gen, RSen_x_rgb 244 244 244 T00 signal white_gen, RSen_x_rgb 0 0 0 T30 aluminium rectangular canvas_gen
Pset Descrizione_Entità - Descrizione_Entità: Unità interna condizionatore
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Unità interna per sistema split a espansione diretta
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: 035131b-c
Abaco IFCGUID - Famiglia e tipo: RSen_55_ME_FB_SOg - fxaq25auv1b - SH_daikin_tbq: standard; WBS_01: DBE; WBS_02: IM; WBS_03: P03

# IfcUnitaryEquipment: Attrezzatura meccanica : RSen_55_ME_FB_SOg - fxaq32auv1b - SH_daikin_tbq : standard
In: A-03-FIN
