Properties of the parts of a building model (IFC4), part 9 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1542703_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542715_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936818_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542707_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542707_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936820_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542708_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936795_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936797_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542708_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936820_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542709_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542709_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936797_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542711_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542713_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542715_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542711_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542764_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542713_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542735_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936791_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1888469_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542735_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1578430_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542764_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936763_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1543880_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1543880_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1578387_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1544566_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936694_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936696_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1544566_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936731_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1544589_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1544589_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936733_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936980_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545164_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545164_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936946_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1545200_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937005_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1545200_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936927_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545685_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545940_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937091_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545685_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545960_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545687_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545687_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937093_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937282_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545689_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545689_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937122_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545705_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545690_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545690_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937154_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937245_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545692_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545692_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937247_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1545694_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1937097_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545694_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545694_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937099_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545694_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937101_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937122_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545695_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545695_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937097_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937099_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545697_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545697_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545707_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937154_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545699_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545699_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937156_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545700_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937245_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937126_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545700_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937156_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545701_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545701_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937126_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545703_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545705_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545707_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545703_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545711_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545705_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545709_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937282_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937284_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545709_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545715_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545711_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545713_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545715_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1545940_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1545713_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937101_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545721_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545721_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545729_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545729_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545723_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1545723_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1545960_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936946_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546333_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546333_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937213_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1546365_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936927_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1546365_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937194_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975191_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546673_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546673_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975212_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546689_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1546674_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1546674_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975239_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975196_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1546676_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1546676_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1857049_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1546678_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1975214_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546678_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546678_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546681_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546678_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975216_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975212_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546679_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546679_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975214_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546681_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546691_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975239_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1546683_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1546683_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975241_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1546684_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975196_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975222_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1546684_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975241_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1546685_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1546685_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975222_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1546687_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546689_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975224_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546687_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546695_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1546689_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1546691_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975224_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546693_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975191_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857015_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546693_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546699_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1546695_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1546697_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1546699_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1547454_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1546697_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975216_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546701_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546701_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546705_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546705_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1546703_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1546703_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1547432_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1547214_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1856942_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1547214_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1881284_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975208_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1547244_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1547244_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1547454_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1547273_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975210_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1547432_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1547273_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548034_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937594_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937564_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548034_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548454_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937584_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937596_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548454_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975082_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548615_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548615_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975113_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548631_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548616_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548616_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975147_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975086_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548618_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548618_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1856952_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1548620_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1975115_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548620_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548620_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975164_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548620_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975117_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975113_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548621_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548621_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975115_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975164_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548623_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548623_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548633_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975147_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548625_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548625_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975149_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548626_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975086_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975123_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548626_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975149_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548627_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548627_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975123_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548629_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548631_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548633_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548629_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548637_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548631_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548635_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975082_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1856987_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548635_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548641_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548637_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548639_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548641_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1549322_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548639_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975117_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548643_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548643_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548647_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548647_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548645_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548645_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1549182_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548649_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1549322_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975109_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548649_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1549182_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548651_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548651_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975111_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975256_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548695_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548695_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550181_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975290_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548795_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548795_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975292_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975294_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548798_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548798_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1857132_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1548800_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1975264_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548800_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548800_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975266_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548800_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975268_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975292_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548801_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548801_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975264_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975266_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548803_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548803_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1549500_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975309_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548805_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548805_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975311_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548806_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975294_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975296_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548806_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975311_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1548807_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1548807_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975296_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1549500_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548809_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548809_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1549504_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548815_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975290_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857097_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548815_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975268_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1548819_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1548819_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550009_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1549497_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1549504_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550127_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1549497_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1549504_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1549505_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1549505_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975309_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550009_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550007_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550007_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550083_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550021_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975258_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550083_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550021_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550119_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550127_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550189_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550119_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550129_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550189_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550191_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550129_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550181_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550179_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550179_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550191_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937613_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550520_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550520_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575013_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922866_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550730_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550730_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922845_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550914_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550894_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550894_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550900_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1550899_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1550900_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550899_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550899_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1551643_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550899_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550922_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1551860_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550904_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550904_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550906_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550905_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880887_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1550906_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1550905_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1551855_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550908_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550908_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1551859_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1553375_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1550914_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1550922_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1553684_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1551643_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1551855_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1551692_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974535_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1553682_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1551692_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1551850_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1553706_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974533_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1551850_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1553256_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1551859_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1551859_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1551860_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1551962_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1553682_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1553684_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1551962_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552064_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974796_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554152_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552064_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974881_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552156_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552156_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974883_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974885_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1552159_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1552159_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880886_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1552161_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1974802_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552161_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552161_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974804_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552161_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974786_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974883_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552162_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552162_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974802_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974804_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552164_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552164_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552396_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974806_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1552166_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1552166_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974808_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1552167_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974885_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974887_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1552167_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974808_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1552168_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1552168_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974887_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1552396_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552170_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552170_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552400_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552176_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974881_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880860_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552176_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552400_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1552178_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1552178_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974806_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974786_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1552184_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552184_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554263_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1552401_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1552400_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554300_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1552401_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1553716_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1553256_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1553361_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1553375_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880803_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1553361_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1553706_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1553704_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1553704_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1553716_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554116_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880850_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880807_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554116_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554154_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554152_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554247_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554154_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554182_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554247_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554263_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554182_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554292_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554300_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554312_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554292_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974794_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554302_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554302_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554312_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880509_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554609_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554609_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554613_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554618_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554610_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554610_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1918258_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1554612_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1554613_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554612_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554612_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554615_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554612_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554627_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554615_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554629_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554625_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554617_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554617_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554619_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554619_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554618_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554629_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554621_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554621_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554631_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554631_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554625_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554627_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918446_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918376_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554631_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554709_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554842_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918460_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1554709_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554961_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554951_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554951_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1918412_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555583_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555575_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555575_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555585_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555582_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555576_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555576_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555856_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555599_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555578_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555578_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555591_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555592_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555580_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555580_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880108_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1555582_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1555585_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555582_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555582_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555587_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880025_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555583_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555587_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555603_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555591_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555593_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555593_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555592_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555597_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555599_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555603_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555597_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555600_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555599_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555891_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555600_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555683_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555835_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555862_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555683_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555779_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555732_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555732_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555881_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555858_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555839_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555839_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555862_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555856_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555854_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555854_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555858_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555881_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555879_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555879_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555891_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880013_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1555946_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1555946_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936413_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1556268_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1880155_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1556268_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936415_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971646_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556656_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556656_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971648_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556657_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875180_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875206_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556657_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1556659_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1971623_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556659_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556659_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556662_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556659_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971603_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971648_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556660_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556660_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971623_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556662_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556676_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971665_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556664_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1556664_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971667_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1556665_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971650_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971652_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556665_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971667_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556666_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1556666_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971652_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971633_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556668_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556668_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556678_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556670_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971646_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565753_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556670_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556678_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556672_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1556672_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971665_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971603_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556674_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556674_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556700_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556676_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971633_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556679_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556678_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1556694_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556679_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565580_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556682_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556682_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971601_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565563_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556690_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1556690_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556694_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1556696_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565580_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556700_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556696_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971599_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1556775_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1556775_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565563_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568979_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1556847_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556847_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1737549_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920014_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1557324_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1557324_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920016_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920045_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1557325_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1557325_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1632893_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1557331_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1920018_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1557331_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1557331_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1919811_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1557331_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920045_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920016_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1557334_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1557334_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920018_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1557338_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928533_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928529_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1557338_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1557339_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1920024_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928535_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1557339_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928533_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1557340_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1557340_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928535_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1557342_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1919818_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920056_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1557342_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1557345_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1919818_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1632853_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1557345_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1557853_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920043_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1632893_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1557853_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920041_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1557882_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1557882_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1632853_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1921928_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1558724_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558724_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1921930_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1921932_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1558725_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1558725_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928464_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1558727_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1920136_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1558727_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558727_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920138_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558727_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920140_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1921930_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1558728_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558728_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920136_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920138_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1558730_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558730_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1558744_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1933246_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1558732_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1558732_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1933272_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1558733_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1921932_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1933270_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1558733_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1558734_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1933270_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1933272_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1558734_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1558744_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1558736_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558736_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1558746_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558738_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1921928_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1928498_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1558738_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558746_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1558740_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1558740_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1933246_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1920140_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1558742_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558742_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1559917_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1558747_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1558746_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1559941_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1558747_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1559070_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1855152_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1920130_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1559070_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1559224_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1928498_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1928500_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1559224_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1928464_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1559250_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1559250_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928466_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1559768_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920132_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1559909_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1559768_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1559907_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1559909_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1559917_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1559907_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1559939_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1559941_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1855152_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1559939_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560893_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560505_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560505_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560515_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560512_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560506_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560506_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1580203_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560525_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560508_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560508_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560519_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560520_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560510_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560510_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922572_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1560512_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1560515_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560512_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560512_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920598_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920598_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560517_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560517_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560529_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560519_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560521_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560521_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560520_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560523_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560525_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920631_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560523_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560526_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560525_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560816_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560526_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560529_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920631_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920625_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560582_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560582_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560808_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560611_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920627_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1580203_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560611_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560808_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560806_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560806_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560816_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922572_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1560864_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1560864_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922574_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1580264_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560893_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1560899_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922535_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922539_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1560899_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562966_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1562952_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562952_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1562956_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562961_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1562953_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1562953_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922913_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1562955_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1562956_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1562955_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562955_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1562958_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562955_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1562970_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562958_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563597_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562960_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1562962_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563602_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1562960_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
