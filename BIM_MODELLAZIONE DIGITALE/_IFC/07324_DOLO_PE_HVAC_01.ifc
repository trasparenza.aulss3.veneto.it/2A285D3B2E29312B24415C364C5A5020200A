Properties of the parts of a building model (IFC4), part 10 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1562962_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1562961_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563597_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1562964_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562964_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563601_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922876_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1562966_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562970_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1859924_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1562980_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922876_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922878_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1562980_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922913_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1562982_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1562982_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922915_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563592_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563601_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1860288_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563592_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563601_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563602_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563915_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563901_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563901_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563905_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563910_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563902_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563902_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860698_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1563904_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1563905_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563904_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563904_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563907_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563904_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563917_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563907_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563929_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563932_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563909_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563909_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563911_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563911_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563910_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563929_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563913_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563913_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563931_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1860745_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563915_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563917_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563949_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563919_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1860745_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920865_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563919_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1860780_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563921_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563921_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1920882_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563992_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563923_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563923_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920964_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563925_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1564016_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1920962_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563925_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563927_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563931_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563943_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563927_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563931_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563932_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1564016_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563939_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563939_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1563943_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1563945_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563992_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1563949_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1563945_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922949_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1564353_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1564353_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922971_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1564356_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1922973_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1564356_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1564356_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1923016_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1564356_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922975_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922971_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1564357_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1564357_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922973_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1564361_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936148_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936144_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1564361_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1564362_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922951_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936150_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1564362_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936148_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1564363_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1564363_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936150_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1869660_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1564365_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1564365_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1564375_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1564369_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936144_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1564375_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1564369_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922975_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1564371_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1564371_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1854315_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1564376_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1564375_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565044_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1564376_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1564381_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922949_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1869838_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1564381_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922951_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1564383_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1564383_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1870155_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922967_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1564480_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1564480_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565036_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565036_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565034_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565034_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565044_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1870631_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565320_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565320_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936382_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971452_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565436_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565436_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971454_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971456_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565437_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565437_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1873465_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1565439_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1971400_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565439_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565439_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971408_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565439_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971410_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971454_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565440_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565440_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971400_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971408_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565442_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565442_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565456_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971566_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565444_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565444_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971568_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565445_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971456_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971458_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565445_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971568_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565446_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565446_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971458_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565456_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565448_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565448_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565458_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565450_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971452_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872275_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565450_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565458_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565452_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565452_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971566_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971410_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565454_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565454_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1872446_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1854354_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565458_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1565743_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565741_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565741_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565753_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565743_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1854860_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872266_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1565743_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1565781_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875180_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566352_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1565781_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971694_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566196_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566196_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971696_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971706_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566197_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566197_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566362_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1566199_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1971698_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566199_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566199_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971721_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566199_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971700_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971696_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566200_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566200_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971698_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971721_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566202_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566202_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566216_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971702_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566204_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566204_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971704_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566205_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971706_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971708_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566205_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971704_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566206_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566206_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971708_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566216_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566208_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566208_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566218_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566210_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971694_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566329_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566210_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566218_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566212_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566212_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971702_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971700_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566214_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566214_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566230_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566219_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566218_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566226_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566219_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566395_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566222_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566222_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971692_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566419_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566224_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566224_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566226_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566228_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566395_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566230_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566228_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566232_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566419_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971690_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566232_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566319_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566317_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566317_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566329_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566319_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569026_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1854860_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566319_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566350_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566352_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566362_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566350_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1569062_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566352_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971789_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566435_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566435_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971791_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971793_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566436_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566436_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566730_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1566438_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1971766_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566438_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566438_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566441_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566438_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971768_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971791_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566439_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566439_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971766_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566441_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566455_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971808_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566443_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566443_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971810_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566444_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971793_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971795_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566444_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971810_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566445_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566445_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971795_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971776_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566447_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566447_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566457_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566449_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971789_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566770_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566449_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566457_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566451_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566451_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971808_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971768_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566453_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566453_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566469_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566455_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971776_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566458_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566457_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566465_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566458_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566675_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566461_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566461_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971762_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566695_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566463_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566463_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566465_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566467_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566675_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566469_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566467_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566471_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566695_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971760_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566471_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566718_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566720_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566730_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566718_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1761907_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566720_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566720_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1569062_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566760_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566758_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566758_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566770_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566760_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1875645_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569026_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566760_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972775_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566843_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566843_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972777_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972779_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566844_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566844_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853864_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1566846_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1972751_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566846_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566846_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972753_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566846_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972755_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972777_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566847_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566847_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972751_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972753_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566849_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566849_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566863_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972794_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566851_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566851_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972796_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566852_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972779_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972781_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566852_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972796_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566853_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566853_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972781_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566863_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566855_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566855_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566865_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566857_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972775_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853814_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566857_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566865_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566859_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1566859_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972794_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972755_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1566861_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566861_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853163_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1566866_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566865_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853195_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1566866_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972867_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567000_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567000_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972869_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972871_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567001_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567001_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567716_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1567003_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1972827_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567003_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567003_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972829_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567003_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972831_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972869_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567004_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567004_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972827_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972829_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567006_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567006_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567020_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972886_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567008_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567008_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972888_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567009_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972871_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972873_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567009_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972888_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567010_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567010_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972873_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567020_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567012_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567012_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567022_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567014_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972867_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567751_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567014_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567022_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567016_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567016_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972886_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972831_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567018_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567018_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567034_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567023_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567022_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567030_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567023_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567116_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567026_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567026_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972821_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567075_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567028_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567028_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567030_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567032_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567116_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567034_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567032_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567036_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567075_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972819_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567036_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972679_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567188_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567188_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972681_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972693_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567189_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567189_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1916594_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1567191_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1972683_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567191_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567191_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972685_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567191_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972687_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972681_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567192_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567192_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972683_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972685_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567194_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567194_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567208_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972717_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567196_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567196_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972719_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567197_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972693_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972695_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567197_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972719_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567198_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567198_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972695_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567208_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567200_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567200_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567210_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567202_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972679_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1916560_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567202_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567210_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567204_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567204_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972717_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972687_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567206_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567206_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1854120_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567211_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567210_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1854045_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567211_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567531_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568943_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1737552_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567531_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567704_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567706_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567716_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567704_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568944_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567706_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567706_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1567707_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567707_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853925_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1567741_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567739_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567739_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567751_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567741_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568980_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1567742_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567741_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853906_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1567742_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853804_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568396_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568396_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853906_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568432_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853854_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853925_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568432_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973000_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568717_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568717_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973002_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973004_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568718_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568718_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568951_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1568720_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1972915_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568720_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568720_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972917_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568720_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972919_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973002_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568721_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568721_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972915_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972917_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568723_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568723_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568737_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973019_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568725_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568725_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973021_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568726_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973004_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973006_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568726_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973021_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568727_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568727_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973006_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568737_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568729_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568729_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568739_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568731_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973000_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568987_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568731_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568739_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568733_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568733_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973019_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972919_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568735_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568735_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568749_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568740_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568739_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568745_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568740_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568743_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568745_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568837_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568743_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568749_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568747_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568747_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568860_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568751_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568987_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568989_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568751_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568951_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568753_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568753_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568953_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568860_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568755_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568755_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972909_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568757_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568837_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972907_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568757_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568941_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568943_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568953_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568941_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568943_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973068_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973102_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1568944_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1568979_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568977_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568977_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568989_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973091_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1568979_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1568980_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973104_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972325_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569608_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569608_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972327_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569609_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972405_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1877814_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1569609_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1569611_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1972293_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569611_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569611_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972295_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569611_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972297_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972327_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569612_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569612_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972293_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972295_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569614_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569614_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1570695_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972344_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1569616_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1569616_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972346_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1569617_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972329_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972331_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1569617_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972346_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1569618_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1569618_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972331_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1570695_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569620_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569620_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1570699_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569622_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972325_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972407_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569622_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972297_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569626_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569626_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569652_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1570699_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1569631_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1569631_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972344_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1878163_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569634_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569634_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1878391_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569638_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1878003_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1878653_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1569638_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1878003_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1569642_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1569642_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1570456_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1569648_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1878163_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569652_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569648_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1569697_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972285_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1878389_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1569697_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972283_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1569729_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1569729_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1878653_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1570456_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1570700_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1570700_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1570699_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972231_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571215_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571215_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972233_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571216_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1758401_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972173_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571216_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972235_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571220_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571220_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1757838_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1571222_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1972169_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571222_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571222_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972171_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571222_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972173_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972233_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571223_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571223_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972169_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972171_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571225_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571225_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571237_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571227_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972364_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972366_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571227_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571228_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972235_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972237_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571228_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571231_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571233_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571237_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571231_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571233_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1758532_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571234_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571233_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571576_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571234_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571261_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972231_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1753540_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571261_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972161_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571300_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571300_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571576_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571329_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972163_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1758401_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571329_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971868_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571721_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571721_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972020_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971872_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571722_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571722_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1877528_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1571724_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1972022_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571724_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571724_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972024_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571724_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972026_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972020_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571725_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571725_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972022_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972024_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571727_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571727_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571741_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972094_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571729_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571729_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972096_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571730_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971872_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972084_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571730_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972096_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571731_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571731_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972084_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571741_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571733_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571733_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571743_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571735_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971868_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1877494_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571735_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972026_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571737_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571737_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1782216_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571743_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571739_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571739_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972094_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1572180_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571743_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1571814_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1878722_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972405_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1571814_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1878683_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1571850_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1571850_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972407_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
