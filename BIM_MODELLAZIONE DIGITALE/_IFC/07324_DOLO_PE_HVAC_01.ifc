Properties of the parts of a building model (IFC4), part 15 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_2142622_1 | SOURCE | PIPE | HEATING | REF 9
InPort_2142662_3 | SINK | PIPE | HEATING | REF 9
OutPort_2142652_0 | SOURCE | PIPE | HEATING | REF 9
InPort_2142652_1 | SINK | PIPE | HEATING | REF 9
OutPort_2142666_2 | SOURCE | PIPE | HEATING | REF 9
Port_2142662_2 | SOURCEANDSINK | PIPE | HEATING | REF 9
Port_2142663_1 | SOURCEANDSINK | PIPE | HEATING | REF 9
InPort_2145716_2 | SINK | PIPE | HEATING | REF 14
OutPort_2143408_0 | SOURCE | PIPE | HEATING | REF 14
InPort_2143408_1 | SINK | PIPE | HEATING | REF 14
OutPort_2145720_2 | SOURCE | PIPE | HEATING | REF 14
Port_2143471_0 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143762_2 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143471_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143764_3 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143524_0 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143532_2 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143524_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143641_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143548_0 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143556_2 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143548_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143708_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143584_0 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143787_2 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143584_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143789_3 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143641_2 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143765_0 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143708_2 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143790_0 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143759_0 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143764_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143759_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2145675_2 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143764_2 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143765_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143789_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143864_0 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143789_2 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143790_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143864_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2145624_2 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143875_0 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2145624_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143875_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2145626_2 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143908_0 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2145675_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143908_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2145677_2 | SOURCEANDSINK | PIPE | HEATING | RIS 6
InPort_2144048_0 | SINK | PIPE | HEATING | REF 8
OutPort_2144050_2 | SOURCE | PIPE | HEATING | REF 8
InPort_2145761_1 | SINK | PIPE | HEATING | REF 8
OutPort_2144048_1 | SOURCE | PIPE | HEATING | REF 8
InPort_2144395_1 | SINK | PIPE | HEATING | REF 14
OutPort_2144414_1 | SOURCE | PIPE | HEATING | REF 14
InPort_2144414_2 | SINK | PIPE | HEATING | REF 14
OutPort_2144406_0 | SOURCE | PIPE | HEATING | REF 14
InPort_2144406_1 | SINK | PIPE | HEATING | REF 14
OutPort_2145716_1 | SOURCE | PIPE | HEATING | REF 14
InPort_2144636_0 | SINK | PIPE | HEATING | REF 8
OutPort_2145761_2 | SOURCE | PIPE | HEATING | REF 8
InPort_2145765_2 | SINK | PIPE | HEATING | REF 8
OutPort_2144636_1 | SOURCE | PIPE | HEATING | REF 8
Port_2145609_0 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2145611_3 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2145609_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2145626_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
InPort_2145612_0 | SINK | PIPE | USERDEFINED | Altro 6
OutPort_2145611_2 | SOURCE | PIPE | HEATING | Altro 6
Port_2145612_1 | SOURCEANDSINK | PIPE | USERDEFINED | Altro 6
Port_2145657_0 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2145659_3 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2145657_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2145677_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
InPort_2145660_0 | SINK | PIPE | USERDEFINED | Altro 7
OutPort_2145659_2 | SOURCE | PIPE | HEATING | Altro 7
Port_2145660_1 | SOURCEANDSINK | PIPE | USERDEFINED | Altro 7
InPort_2145701_0 | SINK | PIPE | HEATING | REF 14
OutPort_2145703_3 | SOURCE | PIPE | HEATING | REF 14
InPort_2145720_1 | SINK | PIPE | HEATING | REF 14
OutPort_2145701_1 | SOURCE | PIPE | HEATING | REF 14
InPort_2145704_0 | SINK | PIPE | USERDEFINED | Altro 1
OutPort_2145703_2 | SOURCE | PIPE | HEATING | Altro 1
Port_2145704_1 | SOURCEANDSINK | PIPE | USERDEFINED | Altro 1
InPort_2145749_3 | SINK | PIPE | HEATING | REF 8
OutPort_2145747_0 | SOURCE | PIPE | HEATING | REF 8
InPort_2145747_1 | SINK | PIPE | HEATING | REF 8
OutPort_2145765_1 | SOURCE | PIPE | HEATING | REF 8
InPort_2145750_0 | SINK | PIPE | USERDEFINED | Altro 8
OutPort_2145749_2 | SOURCE | PIPE | HEATING | Altro 8
Port_2145750_1 | SOURCEANDSINK | PIPE | USERDEFINED | Altro 8
Port_2156695_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156774_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156695_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156697_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156816_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156697_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156821_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156701_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156701_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156706_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156704_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156706_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156704_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156816_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156762_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156764_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156762_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156774_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156764_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156765_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156798_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156800_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156798_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156821_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156800_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156801_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2157157_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2157422_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2157181_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2158745_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2157422_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158486_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2157943_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158486_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2157943_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158490_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158179_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2158180_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2158255_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354107_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158366_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354079_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158478_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158480_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158478_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158490_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158480_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354243_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158745_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2158766_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2158760_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2158766_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2158760_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159020_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159009_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159020_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159009_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159069_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159023_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159069_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159023_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159308_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159129_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159308_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159129_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159310_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2159301_0 | SINK | PIPE | HEATING | REF 13
OutPort_2159310_1 | SOURCE | PIPE | HEATING | REF 13
Port_2159310_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159311_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
OutPort_2161198_1 | SOURCE | PIPE | HEATING | POST 1
InPort_2161348_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2200975_10 | SOURCE | PIPE | HEATING | SR 3
InPort_2200975_11 | SINK | PIPE | HEATING | SR 4
OutPort_2200975_12 | SOURCE | PIPE | SEWAGE
Port_2200975_17 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_2200975_18 | SOURCEANDSINK | CABLE | CONTROL
OutPort_2241811_10 | SOURCE | PIPE | HEATING | REF 6
InPort_2241811_11 | SINK | PIPE | HEATING | REF 7
OutPort_2241811_12 | SOURCE | PIPE | SEWAGE
Port_2241811_17 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_2241811_18 | SOURCEANDSINK | CABLE | CONTROL
OutPort_2306393_10 | SOURCE | PIPE | HEATING | SR 2
InPort_2306393_11 | SINK | PIPE | HEATING | SR 1
OutPort_2306393_12 | SOURCE | PIPE | SEWAGE
InPort_2306393_14 | SINK | DUCT | VENTILATION
Port_2306393_17 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_2306393_18 | SOURCEANDSINK | CABLE | CONTROL
OutPort_2306437_10 | SOURCE | PIPE | HEATING
InPort_2306437_11 | SINK | PIPE | HEATING
OutPort_2306437_12 | SOURCE | PIPE | SEWAGE
InPort_2306437_14 | SINK | DUCT | VENTILATION
Port_2306437_17 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_2306437_18 | SOURCEANDSINK | CABLE | CONTROL
Port_2353202_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353314_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353213_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353317_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353223_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353326_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353234_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2353329_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2353326_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353404_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353404_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353416_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353513_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353535_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353524_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353538_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354079_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354080_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354243_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354325_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354299_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354321_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354299_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354325_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354310_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354312_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354310_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354321_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354312_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354313_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_1427203_7 | SINK | DUCT | EXHAUST | Meccanico Aria di ritorno 19 (1)
OutPort_2354833_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1599164_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 6
OutPort_2354868_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 6
InPort_2356750_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359841_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2360242_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2356769_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2358667_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2358659_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2358659_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2358679_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2359272_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2360190_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2360210_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2359272_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2359825_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359284_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2359284_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359654_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2359413_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359411_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2359628_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359411_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2359654_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359628_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2359814_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359825_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2359844_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359814_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2359841_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2359844_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2360190_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2360181_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2360181_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2360245_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2360201_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2360210_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2360474_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2360201_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2360245_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2360242_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2360404_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2360474_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2360471_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2360404_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2406084_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2406094_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2406107_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2406084_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2406098_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2406107_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
Port_2411918_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2411961_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2411947_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2411964_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
InPort_2434093_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2434095_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434116_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434225_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434294_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434301_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434314_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434294_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434304_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434314_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2437202_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434304_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434369_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434336_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434338_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434369_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434491_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2434493_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434493_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2434800_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434493_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2434799_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434605_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434607_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434800_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2434744_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435965_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434991_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434991_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434993_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2435027_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2435029_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435072_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2435079_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2435077_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2435072_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2435074_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2435077_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2435099_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2435093_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435093_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2435097_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435097_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2435095_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435132_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_2435134_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_2435170_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_2435172_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_2435708_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2470199_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2435841_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2436517_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2435990_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2435965_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2436329_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2435965_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2436517_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2435965_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2436693_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2436709_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2436740_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2436693_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2436704_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2436705_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2436709_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2436704_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2443312_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2443370_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2443963_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2443312_2 | SOURCE | PIPE | HEATING | RIS 10
Port_2443312_3 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_2443322_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2443393_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2443904_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2443322_2 | SOURCE | PIPE | HEATING | RIS 10
Port_2443322_3 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_2443708_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2443904_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2443915_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2443963_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2448488_0 | SINK | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 1
OutPort_2446292_1 | SOURCE | DUCT | VENTILATION | Meccanico Pressurizzazione Filtri 1
OutPort_2448488_1 | SOURCE | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 1
InPort_2448939_0 | SINK | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 2
OutPort_2448714_1 | SOURCE | DUCT | VENTILATION | Meccanico Pressurizzazione Filtri 2
OutPort_2448939_1 | SOURCE | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 2
InPort_2449690_1 | SINK | DUCT | VENTILATION | Meccanico Estrazione cucina 3
OutPort_2449722_0 | SOURCE | DUCT | EXHAUST | Meccanico Estrazione cucina 3
InPort_2449924_1 | SINK | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 3
OutPort_2449722_1 | SOURCE | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 3
InPort_2465286_1 | SINK | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 3
OutPort_2449823_0 | SOURCE | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 3
InPort_2449823_1 | SINK | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 3
OutPort_2449924_0 | SOURCE | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 3
Port_2450097_1 | SOURCEANDSINK | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 4
Port_2450127_0 | SOURCEANDSINK | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 4
Port_2450127_1 | SOURCEANDSINK | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 4
InPort_2465280_0 | SINK | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 3
OutPort_2465286_2 | SOURCE | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 3
OutPort_2465280_1 | SOURCE | DUCT | EXHAUST | Meccanico Pressurizzazione Filtri 3
InPort_2470902_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2470766_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2470889_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2470902_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2470904_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2470889_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2471157_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2471086_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2471086_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2471158_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2471110_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2471119_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2471158_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2471110_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2471732_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2471715_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2471725_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2471732_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2471800_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2471725_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2472404_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2472391_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2

# IfcDistributionSystem: Altro (8)
PredefinedType: USERDEFINED
Name
Altro 2
Altro 3
Altro 4
Altro 5
Altro 6
Altro 7
Altro 1
Altro 8

# IfcDistributionSystem: Aria di mandata (15)
PredefinedType: VENTILATION
Name
Meccanico Aria di mandata 2
Meccanico Aria di mandata 7
Meccanico Aria di mandata 5
Meccanico Aria di mandata 4
Meccanico Aria di mandata 25
Meccanico Aria di mandata 14
Meccanico Aria di mandata 13
Meccanico Aria di mandata 8
Meccanico Aria di mandata 18
Meccanico Aria di mandata 15
Meccanico Aria di mandata 11
Meccanico Aria di mandata 32 (1)
Meccanico Aria di mandata 34
Meccanico Aria di mandata 19 (1)
Meccanico Aria di mandata 1

# IfcDistributionSystem: Aria di ritorno (8)
PredefinedType: VENTILATION
Name
Meccanico Aria di ritorno 1
Meccanico Aria di ritorno 6
Meccanico Aria di ritorno 9
Meccanico Aria di ritorno 14
Meccanico Aria di ritorno 15
Meccanico Aria di ritorno 22
Meccanico Aria di ritorno 19 (1)
Meccanico Aria di ritorno 17

# IfcDistributionSystem: Aria di scarico (9)
PredefinedType: EXHAUST
Name
Meccanico Aria di scarico 1
Meccanico Aria di scarico 7
Meccanico Aria di scarico 9
Meccanico Aria di scarico 11
Meccanico Aria di scarico 2
Meccanico Aria di scarico 3
Meccanico Aria di scarico 5
Meccanico Aria di scarico 4
Meccanico Aria di scarico 6

# IfcDistributionSystem: Aria esterna (9)
PredefinedType: EXHAUST
Name
Meccanico Aria esterna 1
Meccanico Aria esterna 2
Meccanico Aria esterna 6
Meccanico Aria esterna 3
Meccanico Aria esterna 4
Meccanico Aria esterna 5
Meccanico Aria esterna 7
Meccanico Aria esterna 8
Meccanico Aria esterna 9

# IfcDistributionSystem: Estrazione cucina, Meccanico Estrazione cucina 3
PredefinedType: VENTILATION

# IfcDistributionSystem: Mandata Espansione diretta (2)
PredefinedType: HEATING
Name
SR 4
SR 1

# IfcDistributionSystem: Mandata Post, Mandata Post 2 (1) (1)
PredefinedType: HEATING

# IfcDistributionSystem: Mandata Raffrescamento (4)
PredefinedType: HEATING
Name
REF 2
REF 9
REF 14
REF 7

# IfcDistributionSystem: Mandata Riscaldamento (2)
PredefinedType: HEATING
Name
RIS 10
RIS 6

# IfcDistributionSystem: Pressurizzazione Filtri (4)
PredefinedType: EXHAUST
Name
Meccanico Pressurizzazione Filtri 1
Meccanico Pressurizzazione Filtri 2
Meccanico Pressurizzazione Filtri 3
Meccanico Pressurizzazione Filtri 4

# IfcDistributionSystem: Ritorno Espansione diretta (2)
PredefinedType: HEATING
Name
SR 3
SR 2

# IfcDistributionSystem: Ritorno Post (2)
PredefinedType: HEATING
Name
Ritorno Post 1 (1) (1)
POST 1

# IfcDistributionSystem: Ritorno Raffrescamento (3)
PredefinedType: HEATING
Name
REF 13
REF 8
REF 6

# IfcDistributionSystem: Ritorno Riscaldamento (2)
PredefinedType: HEATING
Name
RIS 7
RIS 8

# IfcDuctFitting: Condotto : Condotto rettangolare : Raggio gomiti / T (1234)
Type - PredefinedType: CONNECTOR
Pset Descrizione_Entità - Descrizione_Entità: Raccordo Condotto aeraulico Rettangolare
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Abaco IFCGUID - Famiglia e tipo: Condotto rettangolare: Raggio gomiti / T; WBS_01: DBE; WBS_02: IM
Name (Condotto : Condotto rettangolare :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | RIF_EPU | Main Dimensions | IFC_Descriptions | Group
16 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x200mm | UTA.03.07 | Meccanico Aria di mandata 2
10 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x200mm | UTA.03.07 | Meccanico Aria di mandata 2
7 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x200mm | UTA.03.07 | Meccanico Aria di ritorno 1
11 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x200mm | UTA.03.07 | Meccanico Aria di ritorno 1
25 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x150mm | UTA.03.07 | Meccanico Aria di mandata 2
49 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x150mm | UTA.03.07 | Meccanico Aria di mandata 2
51 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x150mm | UTA.03.07 | Meccanico Aria di ritorno 1
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x200mm | UTA.03.07 | Meccanico Aria di ritorno 1
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x500mm | UTA.03.07 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x250mm | UTA.03.07 | Meccanico Aria di mandata 2
41 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x150mm | UTA.03.07 | Meccanico Aria di ritorno 1
11 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x200mm | UTA.03.07 | Meccanico Aria di mandata 2
35 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x150mm | UTA.03.08 | Meccanico Aria di mandata 2
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x200mm | UTA.03.07 | Meccanico Aria di mandata 2
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x250mm | UTA.03.07 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x300mm | UTA.03.07 | Meccanico Aria di ritorno 1
43 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x150mm | UTA.03.08 | Meccanico Aria di ritorno 1
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x200mm | UTA.03.07 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x200mm | UTA.03.07 | Meccanico Aria di ritorno 1
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x400mm | UTA.03.07 | Meccanico Aria di mandata 2
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x150mm | UTA.03.07 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x350mm | UTA.03.07 | Meccanico Aria di ritorno 1
6 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x150mm | UTA.03.07 | Meccanico Aria di mandata 2
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x500mm | UTA.03.07 | Meccanico Aria di ritorno 1
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x350mm | UTA.03.07 | Meccanico Aria di mandata 2
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x350mm | UTA.03.07 | Meccanico Aria di mandata 2
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x400mm | UTA.03.07 | Meccanico Aria di mandata 2
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 800x500mm | UTA.03.07 | Meccanico Aria di mandata 2
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 800x600mm | UTA.03.07 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x500mm | UTA.03.07 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x600mm | UTA.03.07 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x600mm | UTA.03.07 | Meccanico Aria di mandata 2
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 800x600mm | UTA.03.07 | Meccanico Aria di ritorno 1
38 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x150mm | UTA.03.08 | Meccanico Aria di mandata 2
31 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x150mm | UTA.03.08 | Meccanico Aria di ritorno 1
10 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x200mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x200mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x200mm | UTA.03.08 | Meccanico Aria di mandata 2
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x250mm | UTA.03.08 | Meccanico Aria di ritorno 1
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x250mm | UTA.03.08 | Meccanico Aria di mandata 2
43 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x200mm | UTA.03.08 | Meccanico Aria di ritorno 1
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x250mm | UTA.03.08 | Meccanico Aria di mandata 2
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x250mm | UTA.03.08 | Meccanico Aria di ritorno 1
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x250mm | UTA.03.08 | Meccanico Aria di ritorno 1
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x200mm | UTA.03.08 | Meccanico Aria di ritorno 1
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x250mm | UTA.03.08 | Meccanico Aria di mandata 2
30 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x200mm | UTA.03.08 | Meccanico Aria di mandata 2
36 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x200mm | UTA.03.09 | Meccanico Aria di mandata 7
13 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x200mm | UTA.03.09 | Meccanico Aria di mandata 7
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x450mm | UTA.03.09 | Meccanico Aria di mandata 7
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x450mm | UTA.03.09 | Meccanico Aria di ritorno 6
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 700x450mm | UTA.03.09 | Meccanico Aria di mandata 7
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x400mm | UTA.03.09 | Meccanico Aria di ritorno 6
22 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x200mm | UTA.03.09 | Meccanico Aria di ritorno 6
7 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x600mm | UTA.03.09 | Meccanico Aria di ritorno 6
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x250mm | UTA.03.09 | Meccanico Aria di ritorno 6
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x300mm | UTA.03.08 | Meccanico Aria di mandata 2
6 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 550x550mm | UTA.03.08 | Meccanico Aria di ritorno 1
10 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x200mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 550x500mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 550x400mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x400mm | UTA.03.08 | Meccanico Aria di ritorno 1
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x300mm | UTA.03.08 | Meccanico Aria di ritorno 1
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x300mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | PC | VEN24-12.02.18.01 | 550x700mm | UTA.03.08 | Meccanico Aria di ritorno 1
6 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x500mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | PC | VEN24-12.02.18.01 | 500x700mm | UTA.03.08 | Meccanico Aria di mandata 2
7 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 550x500mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | PC | VEN24-12.02.18.01 | 550x500mm | UTA.03.08 | Meccanico Aria di mandata 2
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 450x450mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | PC | VEN24-12.02.18.01 | 450x450mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 550x400mm | UTA.03.08 | Meccanico Aria di mandata 2
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x400mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x400mm | UTA.03.08 | Meccanico Aria di mandata 2
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x300mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x500mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 450x350mm | UTA.03.08 | Meccanico Aria di ritorno 1
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x150mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x500mm | UTA.03.08 | Meccanico Aria di mandata 2
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x150mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x150mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x450mm | UTA.03.09 | Meccanico Aria di mandata 7
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x200mm | UTA.03.09 | Meccanico Aria di ritorno 6
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x300mm | UTA.03.09 | Meccanico Aria di ritorno 6
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x250mm | UTA.03.09 | Meccanico Aria di ritorno 6
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x400mm | UTA.03.08 | Meccanico Aria di mandata 2
8 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x200mm | UTA.03.09 | Meccanico Aria di ritorno 6
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x350mm | UTA.03.09 | Meccanico Aria di mandata 7
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x450mm | UTA.03.09 | Meccanico Aria di mandata 7
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x200mm | UTA.03.09 | Meccanico Aria di mandata 7
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x300mm | UTA.03.08 | Meccanico Aria di mandata 2
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x300mm | UTA.03.08 | Meccanico Aria di mandata 2
8 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 1100x400mm | UTA.03.06 | Meccanico Aria di mandata 25
4 x  Raggio gomiti / T | A-03-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.06 | Meccanico Aria di mandata 25
4 x  Raggio gomiti / T | A-03-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.06 | Meccanico Aria di ritorno 9
12 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x400mm | UTA.03.06 | Meccanico Aria di ritorno 9
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x600mm | UTA.03.06 | Meccanico Aria di ritorno 9
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x200mm | UTA.03.06 | Meccanico Aria di ritorno 9
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x350mm | UTA.03.06 | Meccanico Aria di ritorno 9
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x650mm | UTA.03.06 | Meccanico Aria di ritorno 9
4 x  Raggio gomiti / T | A-03-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.05 | Meccanico Aria di mandata 8
8 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 1100x400mm | UTA.03.05 | Meccanico Aria di mandata 8
4 x  Raggio gomiti / T | A-03-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.05 | Meccanico Aria di ritorno 14
13 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x400mm | UTA.03.05 | Meccanico Aria di ritorno 14
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x600mm | UTA.03.05 | Meccanico Aria di ritorno 14
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x200mm | UTA.03.05 | Meccanico Aria di ritorno 14
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x350mm | UTA.03.05 | Meccanico Aria di ritorno 14
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x650mm | UTA.03.05 | Meccanico Aria di ritorno 14
8 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.04 | Meccanico Aria di mandata 11
8 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 1100x400mm | UTA.03.04 | Meccanico Aria di mandata 11
16 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.04 | Meccanico Aria di ritorno 15
12 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x400mm | UTA.03.04 | Meccanico Aria di ritorno 15
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x600mm | UTA.03.04 | Meccanico Aria di ritorno 15
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x200mm | UTA.03.04 | Meccanico Aria di ritorno 15
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x350mm | UTA.03.04 | Meccanico Aria di ritorno 15
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x650mm | UTA.03.04 | Meccanico Aria di ritorno 15
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 1410x220mm | UTA.03.01 | Meccanico Aria di mandata 19 (1)
5 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 550x500mm | UTA.03.01 | Meccanico Aria di mandata 19 (1)
7 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x300mm | UTA.03.01 | Meccanico Aria di mandata 19 (1)
6 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 550x500mm | UTA.03.01 | Meccanico Aria di ritorno 22
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 550x500mm | UTA.03.01 | Meccanico Aria di mandata 19 (1)
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 550x500mm | UTA.03.01 | Meccanico Aria di ritorno 22
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x600mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x200mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x350mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x650mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
12 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x200mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x400mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
12 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x200mm | UTA.03.02. | Meccanico Aria di ritorno 17
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x600mm | UTA.03.02. | Meccanico Aria di ritorno 17
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x200mm | UTA.03.02. | Meccanico Aria di ritorno 17
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x350mm | UTA.03.02. | Meccanico Aria di ritorno 17
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x650mm | UTA.03.02. | Meccanico Aria di ritorno 17
13 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x300mm | UTA.03.01 | Meccanico Aria di ritorno 22
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x600mm | UTA.03.01 | Meccanico Aria di ritorno 22
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 600x200mm | UTA.03.01 | Meccanico Aria di ritorno 22
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x350mm | UTA.03.01 | Meccanico Aria di ritorno 22
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x650mm | UTA.03.01 | Meccanico Aria di ritorno 22
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x400mm | UTA.03.01 | Meccanico Aria di ritorno 22
11 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
4 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.02. | Meccanico Aria di mandata 34
9 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.02. | Meccanico Aria di ritorno 17
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 1410x220mm | UTA.03.03 | Meccanico Aria di mandata 32 (1)
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 1410x220mm | UTA.03.02. | Meccanico Aria di mandata 34
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x400mm | UTA.03.03 | Meccanico Aria di mandata 32 (1)
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x400mm | UTA.03.02. | Meccanico Aria di ritorno 17
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 400x400mm | UTA.03.02. | Meccanico Aria di mandata 34
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x400mm | UTA.03.01 | Meccanico Aria di ritorno 22
12 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.06 | Meccanico Aria di ritorno 9
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 800x600mm | UTA.03.06 | Meccanico Aria di ritorno 9
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 600x400mm | UTA.03.06 | Meccanico Aria di ritorno 9
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.06 | Meccanico Aria di mandata 25
4 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.06 | Meccanico Aria di mandata 25
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.06 | Meccanico Aria di scarico 1
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.06 | Meccanico Aria esterna 1
12 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.05 | Meccanico Aria di ritorno 14
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 800x600mm | UTA.03.05 | Meccanico Aria di ritorno 14
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 600x400mm | UTA.03.05 | Meccanico Aria di ritorno 14
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.05 | Meccanico Aria di mandata 8
4 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.05 | Meccanico Aria di mandata 8
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.05 | Meccanico Aria di scarico 2
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.05 | Meccanico Aria esterna 3
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 800x600mm | UTA.03.04 | Meccanico Aria di ritorno 15
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 600x400mm | UTA.03.04 | Meccanico Aria di ritorno 15
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.04 | Meccanico Aria di mandata 11
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.04 | Meccanico Aria di scarico 3
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.04 | Meccanico Aria esterna 4
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 500x500mm | UTA.03.03 | Meccanico Aria di mandata 32 (1)
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 500x500mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1160x550mm | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1160x550mm | UTA.03.03 | Meccanico Aria di mandata 32 (1)
4 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x400mm | UTA.03.03 | Meccanico Aria di mandata 32 (1)
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1150x550mm | UTA.03.02. | Meccanico Aria di scarico 5
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 500x500mm | UTA.03.02. | Meccanico Aria di mandata 34
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 500x500mm | UTA.03.02. | Meccanico Aria di ritorno 17
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1160x550mm | UTA.03.02. | Meccanico Aria di ritorno 17
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1160x550mm | UTA.03.01 | Meccanico Aria di mandata 19 (1)
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1160x550mm | UTA.03.01 | Meccanico Aria di ritorno 22
2 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 500x550mm | UTA.03.01 | Meccanico Aria di mandata 19 (1)
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 500x550mm | UTA.03.01 | Meccanico Aria di ritorno 22
5 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 700x450mm | UTA.03.09 | Meccanico Aria di ritorno 6
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 800x600mm | UTA.03.07 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 800x600mm | UTA.03.07 | Meccanico Aria di ritorno 1
4 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 500x450mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 550x500mm | UTA.03.08 | Meccanico Aria di mandata 2
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 550x700mm | UTA.03.08 | Meccanico Aria di ritorno 1
3 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1000x700mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1000x700mm | UTA.03.08 | Meccanico Aria di ritorno 1
2 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 500x700mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.05 | Meccanico Aria di ritorno 14
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.06 | Meccanico Aria di ritorno 9
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.04 | Meccanico Aria di ritorno 15
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1160x550mm | UTA.03.02. | Meccanico Aria di mandata 34
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1500x700mm | UTA.03.09 | Meccanico Aria di mandata 7; Meccanico Aria esterna 8
5 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 600x800mm | UTA.03.07 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1200x855mm | UTA.03.07 | Meccanico Aria di mandata 2
4 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1000x600mm | UTA.03.07 | Meccanico Aria di scarico 9
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1500x700mm | UTA.03.09 | Meccanico Aria di mandata 7
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1500x700mm | UTA.03.09 | Meccanico Aria di scarico 11
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 2320x220mm | UTA.03.06 | Meccanico Aria di mandata 5
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 2320x220mm | UTA.03.06 | Meccanico Aria di mandata 4
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 1100x200mm | UTA.03.06 | Meccanico Aria di mandata 25
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 2320x220mm | UTA.03.04 | Meccanico Aria di mandata 15
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 2320x220mm | UTA.03.04 | Meccanico Aria di mandata 18
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 1100x200mm | UTA.03.04 | Meccanico Aria di mandata 11
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 2320x220mm | UTA.03.05 | Meccanico Aria di mandata 14
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 2320x220mm | UTA.03.05 | Meccanico Aria di mandata 13
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 1100x200mm | UTA.03.05 | Meccanico Aria di mandata 8
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1200x855mm | UTA.03.07 | Meccanico Aria di scarico 9
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1200x855mm | UTA.03.07 | Meccanico Aria di mandata 2; Meccanico Aria esterna 9
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1200x855mm | UTA.03.07 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1500x700mm | UTA.03.09 | Meccanico Aria di ritorno 6
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.08 | Meccanico Aria di scarico 4
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.08 | Meccanico Aria di mandata 1; Meccanico Aria esterna 7
2 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1200x700mm | UTA.03.08 | Meccanico Aria di scarico 4
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.08 | Meccanico Aria di ritorno 1
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1800x700mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1160x550mm | UTA.03.03 | Meccanico Aria esterna 2
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1160x550mm | UTA.03.03 | Meccanico Aria di scarico 6
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1150x550mm | UTA.03.02. | Meccanico Aria esterna 5
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1150x550mm | UTA.03.01 | Meccanico Aria esterna 6
 Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 1150x550mm | UTA.03.01 | Meccanico Aria di scarico 7
4 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 700x700mm | UTA.03.09 | Meccanico Aria di scarico 11
2 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x600mm | UTA.03.04 | Meccanico Aria di mandata 11
2 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x600mm | UTA.03.05 | Meccanico Aria di mandata 8
2 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x600mm | UTA.03.06 | Meccanico Aria di mandata 25
2 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x500mm | UTA.03.02. | Meccanico Aria di mandata 34
2 x  Raggio gomiti / T | A-04-FIN | PC | VEN24-12.02.18.01 | 400x500mm | UTA.03.03 | Meccanico Aria di mandata 32 (1)
4 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 350x200mm | UTA.03.07 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x250mm | UTA.03.07 | Meccanico Aria di mandata 2
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x150mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x300mm | UTA.03.08 | Meccanico Aria di mandata 2
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x300mm | UTA.03.07 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x300mm | UTA.03.07 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x500mm | UTA.03.07 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 250x350mm | UTA.03.09 | Meccanico Aria di mandata 7
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x350mm | UTA.03.09 | Meccanico Aria di mandata 7
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x300mm | UTA.03.08 | Meccanico Aria di ritorno 1
7 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x150mm |  | Meccanico Aria di ritorno 1
3 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 150x150mm |  | Meccanico Aria di mandata 2
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x200mm |  | Meccanico Aria di ritorno 1
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 700x500mm |  | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 300x250mm | UTA.03.08 | Meccanico Aria di mandata 2
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 500x250mm |  | Meccanico Aria di mandata 2
2 x  Raggio gomiti / T | A-03-FIN | P03 | M19.idp.001 | 210x210mm |  | Meccanico Pressurizzazione Filtri 3
 Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 | 200x150mm |  | Meccanico Aria di ritorno 1
2 x  Raggio gomiti / T | A-03-FIN | P03 | VEN24-12.02.18.01 |  |  | Meccanico Aria di mandata 2

# IfcDuctFitting: Raccordi condotto : M_Calotta di chiusura rettangolare : Standard (55)
Type - PredefinedType: OBSTRUCTION; Classification: 5.4.1 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Calotta di chiusura condotto aeraulico
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Abaco IFCGUID - Famiglia e tipo: M_Calotta di chiusura rettangolare: Standard; WBS_01: DBE; WBS_02: IM
Name (Raccordi condotto : M_Calotta di chiusura rettangolare :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | IFC_Descriptions | Group
9 x  Standard | A-03-FIN | P03 | UTA.03.07 | Meccanico Aria di ritorno 1
4 x  Standard | A-03-FIN | P03 | UTA.03.08 | Meccanico Aria di ritorno 1
7 x  Standard | A-03-FIN | P03 | UTA.03.09 | Meccanico Aria di ritorno 6
4 x  Standard | A-03-FIN | P03 | UTA.03.06 | Meccanico Aria di ritorno 9
4 x  Standard | A-03-FIN | P03 | UTA.03.05 | Meccanico Aria di ritorno 14
4 x  Standard | A-03-FIN | P03 | UTA.03.04 | Meccanico Aria di ritorno 15
2 x  Standard | A-03-FIN | P03 | UTA.03.01 | Meccanico Aria di mandata 19 (1)
4 x  Standard | A-03-FIN | P03 | UTA.03.03 | Meccanico Aria di ritorno 19 (1)
4 x  Standard | A-03-FIN | P03 | UTA.03.02. | Meccanico Aria di ritorno 17
4 x  Standard | A-03-FIN | P03 | UTA.03.01 | Meccanico Aria di ritorno 22
2 x  Standard | A-03-FIN | P03 | UTA.03.03 | Meccanico Aria di mandata 32 (1)
2 x  Standard | A-03-FIN | P03 | UTA.03.02. | Meccanico Aria di mandata 34
 Standard | A-04-FIN | PC | UTA.03.06 | Meccanico Aria di ritorno 9
 Standard | A-04-FIN | PC | UTA.03.05 | Meccanico Aria di ritorno 14
 Standard | A-04-FIN | PC | UTA.03.04 | Meccanico Aria di ritorno 15
 Standard | A-03-FIN | P03 |  | Meccanico Aria di mandata 2
 Standard | A-03-FIN | P03 |  | Meccanico Aria di ritorno 1

# IfcDuctFitting: Raccordi condotto : M_Deviatore circolare : Standard
In: A-03-FIN
Type - PredefinedType: TRANSITION; Classification: 5.4.1 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Deviatore circolare condotto aeraulico
Pset WBS - WBS_01: DBE; WBS_02: IM; WBS_03: P03
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
Abaco IFCGUID - Famiglia e tipo: M_Deviatore circolare: Standard; WBS_01: DBE; WBS_02: IM; WBS_03: P03
AB_ProperySet - IFC_Descriptions: UTA.03.07
Group: Meccanico Aria di ritorno 1

# IfcDuctFitting: Raccordi condotto : M_Giunto rettangolare - Smussato : Standard (173)
Type - PredefinedType: TRANSITION; Classification: 5.4.1 (Default Classification); Material: <Unnamed>
Pset Descrizione_Entità - Descrizione_Entità: Giunto rettangolare Smussato
Pset WBS - WBS_01: DBE; WBS_02: IM
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.1.4
Pset Main Mechanical Data - Main Mechanical Data: Canalizzazione in pannello sandwich antimicrobico
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-12.02.18.01
