Properties of the parts of a building model (IFC4), part 12 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1645326_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1645350_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1645350_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1645341_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
Port_1645516_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645525_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645583_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645626_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645921_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1646015_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1645941_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1645995_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1646151_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646332_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646175_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646311_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1647287_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652256_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647303_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652323_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647319_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652441_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647335_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652395_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647363_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647363_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647420_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647418_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647420_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647418_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647657_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647459_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647746_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647459_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647467_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647496_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647941_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647496_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647504_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647530_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647855_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647530_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647538_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647562_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647564_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647562_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647702_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647594_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647596_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647594_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647790_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647638_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647640_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647638_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647662_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647640_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647641_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647640_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647775_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647641_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353538_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647684_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647686_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647684_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647707_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647686_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647687_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647686_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647731_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647687_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353535_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647728_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647730_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647728_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647751_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647730_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647731_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647730_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648240_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647772_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647774_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647772_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647795_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647774_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647775_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647774_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648195_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647836_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647838_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647836_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647860_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647838_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647839_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647839_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647885_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647883_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647885_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647883_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648016_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647885_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647886_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647886_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2411964_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647923_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647925_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647923_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647946_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647925_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647926_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647925_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656250_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647926_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2411961_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648003_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648005_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648003_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648021_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648043_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648045_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648043_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656265_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648104_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648106_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648104_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648116_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648106_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648107_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648107_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648239_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648144_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648146_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648144_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648156_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648146_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648147_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648147_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648194_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648192_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648194_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648192_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648204_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648194_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648195_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648237_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648239_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648237_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648249_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648239_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648240_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648431_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650204_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648431_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648439_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648480_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650121_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648480_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648488_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648514_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648516_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648514_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648565_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648547_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648549_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648547_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648570_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648549_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650057_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
InPort_1648550_1 | SINK | PIPE | HEATING | REF 2
OutPort_1648549_2 | SOURCE | PIPE | HEATING | REF 2
Port_1648593_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648595_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648593_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648639_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648595_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648702_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_1648595_2 | SINK | PIPE | HEATING | REF 13
OutPort_1648596_1 | SOURCE | PIPE | HEATING | REF 13
Port_1648626_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648628_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648626_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648644_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648666_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648668_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648666_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650072_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648699_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648701_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648699_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648711_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648701_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648702_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648738_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648740_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648738_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648746_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648772_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648774_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648772_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648898_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648804_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648806_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648804_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648853_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648835_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648837_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648835_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648858_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648837_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648966_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648837_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648838_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648838_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650303_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648880_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648882_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648880_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648903_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648882_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648883_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648883_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648927_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648925_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648927_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648925_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649056_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648927_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648928_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648928_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650105_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648963_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648965_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648963_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649016_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648965_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648966_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649003_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649005_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649003_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649021_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649043_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649045_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649043_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649061_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649083_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649495_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649083_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649091_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649117_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649119_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649117_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649585_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649166_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649168_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649166_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649950_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649215_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649217_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649215_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649676_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649247_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649249_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649247_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649779_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649279_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649281_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649279_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649540_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649311_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649313_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649311_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649630_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649343_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649345_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649343_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649735_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649375_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649377_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649375_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649823_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649445_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649447_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649445_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649905_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649477_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649479_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649477_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649500_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649479_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649480_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649480_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649614_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649522_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649524_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649522_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649545_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649524_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649525_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649525_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649569_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649567_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649569_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649567_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649590_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649569_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649570_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649570_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649889_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649612_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649614_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649612_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649635_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649614_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649615_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649615_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649852_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649658_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649660_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649658_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649681_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649660_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649661_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649661_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649807_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649717_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649719_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649717_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649740_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649719_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649720_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649720_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649763_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649761_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649763_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649761_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649784_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_1649763_2 | SINK | PIPE | HEATING | REF 13
OutPort_1649764_1 | SOURCE | PIPE | HEATING | REF 13
Port_1649805_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649807_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649805_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649828_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
InPort_1649808_1 | SINK | PIPE | HEATING | REF 2
OutPort_1649807_2 | SOURCE | PIPE | HEATING | REF 2
Port_1649850_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649852_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649850_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649862_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649852_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649853_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649853_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649979_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649887_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649889_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649887_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649910_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649889_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649890_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649890_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649934_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649932_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649934_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649932_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649955_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_1649934_2 | SINK | PIPE | HEATING | RIS 7
OutPort_1649935_1 | SOURCE | PIPE | HEATING | RIS 7
Port_1649977_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649979_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649977_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649989_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_1649980_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1649979_2 | SOURCE | PIPE | HEATING | RIS 10
Port_1650054_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650056_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650054_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650077_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650056_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650057_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650103_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650105_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650103_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650126_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650105_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650106_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650106_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650188_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650186_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650188_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650186_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650209_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_1650188_2 | SINK | PIPE | HEATING | RIS 7
OutPort_1650189_1 | SOURCE | PIPE | HEATING | RIS 7
Port_1650261_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650263_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650261_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650273_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650263_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650304_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_1650264_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1650263_2 | SOURCE | PIPE | HEATING | RIS 10
Port_1650301_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650303_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650301_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650313_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650303_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650304_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_1650936_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1650976_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1650989_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1651028_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1651041_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1651144_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1651059_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1651211_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1651609_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1651598_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1651598_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1651920_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
Port_1652113_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652332_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652113_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652115_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652152_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652115_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652117_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652446_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652117_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652121_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652271_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652121_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652276_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652123_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652406_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652123_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652411_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652134_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652134_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652139_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652137_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652139_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652137_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652271_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652149_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652406_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652149_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652152_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652253_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652255_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652253_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652276_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652255_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353524_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652255_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652256_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652320_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652322_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652320_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652332_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652322_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353513_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652322_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652323_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652392_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652394_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652392_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652411_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652394_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2411918_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652394_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652395_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652438_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652440_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652438_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652446_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652440_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2411947_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652440_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652441_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652493_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652943_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652493_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652495_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652520_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652495_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652497_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652714_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652497_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652499_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652876_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652499_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652881_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652501_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652762_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652501_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652767_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652508_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652508_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652513_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652511_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652513_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652511_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652876_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652517_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652762_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652517_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652520_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652701_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652703_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652701_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652714_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
InPort_1652803_0 | SINK | PIPE | HEATING | REF 2
OutPort_1652703_2 | SOURCE | PIPE | HEATING | REF 2
Port_1652744_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652746_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652744_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652767_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652746_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652747_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2001782_1 | SINK | PIPE | HEATING | REF 2
OutPort_1652803_1 | SOURCE | PIPE | HEATING | REF 2
Port_1652858_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652860_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652858_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652881_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652860_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156801_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652860_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652861_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652931_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652933_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652931_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652943_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1652933_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156765_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_1652934_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1652933_2 | SOURCE | PIPE | HEATING | RIS 10
Port_1652967_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652992_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652967_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652969_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653933_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652969_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652973_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653010_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652973_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653877_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652980_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652980_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652985_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652983_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652985_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652983_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653022_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652989_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653010_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652989_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652992_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653022_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653460_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653350_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653933_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653350_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653936_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653398_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653877_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653398_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653880_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653422_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653422_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653753_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653431_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653753_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653431_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653756_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653460_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653655_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653469_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653655_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653469_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653658_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653637_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653639_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653637_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653658_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653639_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353202_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653639_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653640_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653735_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653737_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653735_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653756_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653737_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353213_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653737_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653738_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653859_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653861_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653859_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653880_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653861_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2353234_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653861_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653862_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653915_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653917_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653915_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653936_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653917_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353223_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653917_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653918_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
InPort_1654841_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1653983_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1653983_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1654843_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1654604_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1773189_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1654843_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1654604_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1654900_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1654911_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1654982_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1654900_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1654915_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1654982_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1655098_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1654915_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
Port_1655603_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2411828_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1655625_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2411825_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656247_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656249_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656247_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656270_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656249_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656250_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_1657828_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1657829_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1657839_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1657828_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1922562_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1744233_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1744233_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1935852_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1744267_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922527_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922845_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1744267_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1752810_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1756768_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1756857_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1752845_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1753456_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973516_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973518_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1753456_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1753504_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1753540_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973588_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1753504_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1753594_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974177_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974179_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1753594_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1756768_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972189_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972187_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1756857_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875644_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1757599_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1757599_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1919275_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1757838_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1758195_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973999_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1758159_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1758159_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974001_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1758195_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973610_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1758532_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972366_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1758639_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972237_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972364_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1758639_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1758773_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973502_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973306_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1758773_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973359_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1758794_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1758794_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973332_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973369_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1758875_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1758875_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973371_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875678_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1761907_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1769993_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1769974_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1769974_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937625_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1769989_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1769987_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1769987_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1769993_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937627_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1770012_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1770012_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1770083_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1770083_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1770022_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1770022_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1770085_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1770085_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1770078_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1770078_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1857270_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1770086_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1770085_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937619_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1770086_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1856977_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1770191_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1770191_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1881340_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1771559_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775108_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1771565_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2436759_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775108_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1771565_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1771565_5 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1773416_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1771565_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1773457_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1771565_7 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775056_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1773749_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1774921_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1822316_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1773749_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1774314_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1823710_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1774921_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1774466_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1774466_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1774687_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434336_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1774480_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1774480_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2437202_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1774687_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434338_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1775057_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775002_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775026_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775057_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775056_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775026_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434225_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1775176_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1775176_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1808658_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1775891_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775680_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775680_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775919_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775880_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775759_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775759_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775891_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775966_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775961_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775961_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775965_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775965_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775963_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1776001_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1776035_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1776037_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1776001_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1776003_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1776037_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1819531_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1776696_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1776696_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1776788_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1776788_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1776732_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1937217_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1777151_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1777151_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1887569_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1777215_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937192_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1777215_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1887602_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972016_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1781473_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1781473_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1781607_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1781607_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1781605_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1781605_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1781615_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1782120_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972018_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1782210_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1782120_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1782208_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1782210_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1782218_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1782208_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1783511_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1783873_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1783551_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1783511_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1798270_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1783551_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1784873_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1790480_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1874393_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1786643_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1786643_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1786692_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1786692_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797308_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1915463_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1786692_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1915448_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1786697_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1786697_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1915459_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1788178_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1788177_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1788177_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1788187_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1789013_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1791298_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1791298_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1791291_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1791654_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1791647_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1796031_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1800976_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1803110_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1796031_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1801818_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1796031_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1796896_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1798055_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1796898_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1796896_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797002_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1796896_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797026_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1796956_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1796956_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797009_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797012_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797002_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797009_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797008_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797008_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797012_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797553_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797666_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797636_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797643_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797666_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797636_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797922_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434605_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1915036_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797922_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1798055_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1915521_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1915034_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1798270_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1877336_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1798939_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1800370_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1800377_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1876930_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1800370_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1800976_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1801152_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1801152_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1801107_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1801107_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1807467_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1807467_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1801172_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1801172_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1807469_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1803058_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1801818_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1807469_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1803330_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1807264_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1807022_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1807032_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1807264_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1807265_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1807032_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1815032_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1807713_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1824054_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1808185_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1808185_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1824056_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1808658_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434304_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1808973_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1808975_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1809082_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1809080_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1810711_9 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1809082_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_2434301_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1809129_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1809258_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1809285_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1809883_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1810130_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810133_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1809883_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1809885_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1810133_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1809931_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1810154_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810157_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1809931_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1809933_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1810157_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1809992_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1810014_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810189_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1810196_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810194_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1810189_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810191_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1810194_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810312_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1810310_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1810338_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1810340_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
