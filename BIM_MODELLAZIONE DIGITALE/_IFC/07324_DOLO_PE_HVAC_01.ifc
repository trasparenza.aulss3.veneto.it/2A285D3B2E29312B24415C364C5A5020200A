Properties of the parts of a building model (IFC4), part 11 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1781613_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1572180_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1572190_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1781613_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1781615_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1572190_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1782216_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1572470_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1572470_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1782218_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1573262_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974081_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972185_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1573262_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1573284_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972187_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972189_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1573284_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1573704_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975371_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975373_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1573704_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975371_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1573871_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1573871_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1573890_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1573890_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1573880_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1573880_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574392_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1573905_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975373_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1573925_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1573905_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1573914_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1573925_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574418_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1573914_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574068_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975392_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574645_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574068_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574095_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574390_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574392_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574095_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574390_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574106_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574106_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574125_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975396_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574119_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574119_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574608_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574125_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574457_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937362_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574153_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574153_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937364_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574169_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574154_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574154_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937382_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1574158_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1937331_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574158_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574158_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937333_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574158_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937335_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937364_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574159_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574159_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937331_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937333_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574161_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574161_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574171_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937382_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574163_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574163_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937384_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574164_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937366_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937368_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574164_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937384_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574165_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574165_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937368_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574167_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574169_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574171_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574167_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574175_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574169_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1887483_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574175_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937335_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574181_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574181_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1887368_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574441_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574418_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975392_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574439_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574439_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1975394_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1975394_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574441_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574455_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975396_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975398_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574455_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574457_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975398_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574596_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574598_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574608_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574596_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1574598_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1574599_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1574599_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2032703_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574635_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574633_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574633_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574645_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574636_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574635_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2032709_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574636_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574871_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937564_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574888_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574871_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1574880_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574888_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575013_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1574880_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937594_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574903_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574903_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574920_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574920_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574912_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574912_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574978_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574960_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937617_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574982_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574960_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574978_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574968_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574968_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1574982_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575025_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937613_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937615_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575025_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575806_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575027_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575027_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937615_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937617_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1575055_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575055_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937619_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575341_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937596_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575358_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575341_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575350_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575358_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575462_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575350_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937584_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1575373_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575373_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1769989_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575435_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575804_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575806_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575435_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937621_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575442_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575442_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575466_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575454_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575462_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575466_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575454_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575515_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937621_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937623_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575515_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575804_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575517_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575517_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937623_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937625_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1575529_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575529_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937627_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575807_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575806_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857232_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575807_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1575822_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974107_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974109_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1575822_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575880_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1752810_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973445_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575880_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1752845_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1575912_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575912_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973476_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575951_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972185_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974234_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1575951_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974081_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1575997_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1575997_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974099_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1576328_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576283_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576283_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974240_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974240_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576293_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576293_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974242_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576348_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576328_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974177_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576346_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576346_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972241_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972241_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576348_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576360_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973999_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974107_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1576360_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1576498_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576492_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576492_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973443_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973443_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576494_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576494_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973445_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576503_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576498_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973516_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576502_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576502_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972249_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972249_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1576503_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1576505_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973369_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973474_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1576505_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1576506_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973474_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973476_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1576506_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1578377_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1578379_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1578387_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1578377_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1578422_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1578420_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1578420_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1578430_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1579753_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833390_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1579771_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1579753_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1579764_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1579771_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1579865_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1579764_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1632346_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1579865_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434993_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1580066_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1922535_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1580254_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1580254_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1580264_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1437991_1 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 1
OutPort_1588828_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 1
InPort_2409125_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_1590520_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_1590544_1 | SINK | DUCT | EXHAUST | Meccanico Aria esterna 9
OutPort_1427356_5 | SOURCE | DUCT | VENTILATION | Meccanico Aria esterna 9
InPort_1591506_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1869453_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1591563_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_2427118_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1592676_1 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 4
OutPort_1592475_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 4
InPort_1592844_0 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 4
OutPort_1592676_2 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 4
InPort_1592797_1 | SINK | DUCT | EXHAUST | Meccanico Aria esterna 7
OutPort_1454064_5 | SOURCE | DUCT | VENTILATION | Meccanico Aria esterna 7
InPort_1592861_1 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 4
OutPort_1592844_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 4
InPort_1592854_0 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 4
OutPort_1592861_2 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 4
InPort_1592903_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 4
OutPort_1592854_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 4
InPort_1592854_1 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 4
OutPort_1592903_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 4
InPort_1593041_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1868230_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1629022_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1593167_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1597789_0 | SINK | DUCT | USERDEFINED | Meccanico Aria esterna 2
OutPort_2354815_2 | SOURCE | DUCT | USERDEFINED | Meccanico Aria esterna 2
InPort_2354859_2 | SINK | DUCT | EXHAUST | Meccanico Aria esterna 2
OutPort_1597789_1 | SOURCE | DUCT | USERDEFINED | Meccanico Aria esterna 2
InPort_1597914_1 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 2
OutPort_2354859_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria esterna 2
InPort_1598019_0 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 6
OutPort_2354833_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 6
InPort_2354868_2 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 6
OutPort_1598019_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 6
InPort_2354868_1 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 6
OutPort_1599164_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 6
InPort_1599542_1 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 5
OutPort_1599279_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria esterna 5
InPort_1599860_1 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 6
OutPort_1599777_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria esterna 6
InPort_1599979_1 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 7
OutPort_1600081_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 7
InPort_2001729_2 | SINK | PIPE | HEATING | REF 2
OutPort_1608073_0 | SOURCE | PIPE | HEATING | REF 2
InPort_1608073_1 | SINK | PIPE | HEATING | REF 2
OutPort_2001778_2 | SOURCE | PIPE | HEATING | REF 2
InPort_1608211_2 | SINK | PIPE | HEATING | RIS 10
OutPort_1608427_0 | SOURCE | PIPE | HEATING | RIS 10
Port_1608261_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1608493_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1608261_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1608525_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1608381_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1608851_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1608381_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1608865_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_1608427_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1608444_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_1608444_2 | SINK | PIPE | HEATING | RIS 10
OutPort_1608438_0 | SOURCE | PIPE | HEATING | RIS 10
InPort_1608438_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1608947_2 | SOURCE | PIPE | HEATING | RIS 10
Port_1608517_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1608525_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1608517_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1608921_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1608857_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1608865_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1608857_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1609201_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1608921_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1652861_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_1608947_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1652934_0 | SOURCE | PIPE | HEATING | RIS 10
Port_1609201_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652747_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_1609443_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1609426_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1609436_0 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1609443_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1609453_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1609436_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1609448_0 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1609453_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1609769_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1609448_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1609531_0 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1609769_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1475185_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1609531_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1621855_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1621855_2 | SOURCE | PIPE | SEWAGE
OutPort_1621855_3 | SOURCE | PIPE | USERDEFINED
Port_1621855_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_1621855_5 | SOURCE | PIPE | USERDEFINED
InPort_1621855_6 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1621855_7 | SOURCE | PIPE | SEWAGE
InPort_1621855_8 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1622770_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1622770_2 | SOURCE | PIPE | SEWAGE
OutPort_1622770_3 | SOURCE | PIPE | USERDEFINED
Port_1622770_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_1622770_5 | SOURCE | PIPE | USERDEFINED
InPort_1622770_6 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1622770_7 | SOURCE | PIPE | SEWAGE
InPort_1622770_8 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1622792_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1622792_2 | SOURCE | PIPE | SEWAGE
OutPort_1622792_3 | SOURCE | PIPE | USERDEFINED
Port_1622792_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_1622792_5 | SOURCE | PIPE | USERDEFINED
InPort_1622792_6 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1622792_7 | SOURCE | PIPE | SEWAGE
InPort_1622792_8 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1623194_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1623194_2 | SOURCE | PIPE | SEWAGE
OutPort_1623194_3 | SOURCE | PIPE | USERDEFINED
Port_1623194_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_1623194_5 | SOURCE | PIPE | USERDEFINED
InPort_1623194_6 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1623194_7 | SOURCE | PIPE | SEWAGE
InPort_1623194_8 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1623354_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1623354_2 | SOURCE | PIPE | SEWAGE
OutPort_1623354_3 | SOURCE | PIPE | USERDEFINED
Port_1623354_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_1623354_5 | SOURCE | PIPE | USERDEFINED
InPort_1623354_6 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1623354_7 | SOURCE | PIPE | SEWAGE
InPort_1623354_8 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1623580_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1623580_2 | SOURCE | PIPE | SEWAGE
OutPort_1623580_3 | SOURCE | PIPE | USERDEFINED
Port_1623580_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_1623580_5 | SOURCE | PIPE | USERDEFINED
InPort_1623580_6 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1623580_7 | SOURCE | PIPE | SEWAGE
InPort_1623580_8 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1624245_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1624245_2 | SOURCE | PIPE | SEWAGE
OutPort_1624245_3 | SOURCE | PIPE | USERDEFINED
Port_1624245_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_1624245_5 | SOURCE | PIPE | USERDEFINED
InPort_1624245_6 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1624245_7 | SOURCE | PIPE | SEWAGE
InPort_1624245_8 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1624273_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1624273_2 | SOURCE | PIPE | SEWAGE
OutPort_1624273_3 | SOURCE | PIPE | USERDEFINED
Port_1624273_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_1624273_5 | SOURCE | PIPE | USERDEFINED
InPort_1624273_6 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1624273_7 | SOURCE | PIPE | SEWAGE
InPort_1624273_8 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1624886_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1624886_2 | SOURCE | PIPE | SEWAGE
OutPort_1624886_3 | SOURCE | PIPE | USERDEFINED
Port_1624886_4 | SOURCEANDSINK | CABLE | ELECTRICAL
OutPort_1624886_5 | SOURCE | PIPE | USERDEFINED
InPort_1624886_6 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_1624886_7 | SOURCE | PIPE | SEWAGE
InPort_1624886_8 | SINK | PIPE | DOMESTICCOLDWATER
InPort_1628658_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1628603_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1628603_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1628656_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1645341_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1629022_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1629422_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2465879_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1629471_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1629422_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1921864_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1630197_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1630197_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1935734_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1834102_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1631240_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1631341_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920014_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1631597_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1631341_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920024_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1631355_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1631355_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1631632_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1631587_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1631585_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1631585_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1631597_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920230_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1631587_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1631620_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1631622_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1631632_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1631620_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1631622_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1920280_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1935686_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1631715_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1631715_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1935688_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1631764_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1935740_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1935742_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1631764_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1632173_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1921864_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928231_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1632173_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1921810_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1632203_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1632203_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1928250_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1632213_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1921810_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1935678_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1632213_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1632571_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1632346_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1632541_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1632571_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1833461_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1632541_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
Port_1632970_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1652746_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1632970_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634075_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1632984_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1652703_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1632984_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1634115_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1633047_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2156800_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1633047_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1634262_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1633272_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2156764_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1633272_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1634200_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1634075_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1653862_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634115_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1653918_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1634200_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1653738_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1634262_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1653640_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_1634327_0 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_2409126_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_1634347_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_1634327_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_1634342_0 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_1634347_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_1634665_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_1634342_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_1634351_0 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_1634665_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_1475221_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_1634351_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
Port_1634798_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635193_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1634798_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635836_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1634802_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635076_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1634802_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635759_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1634853_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634904_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634853_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634910_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634895_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2411825_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634895_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647335_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634904_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635626_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634910_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1655625_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634910_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634911_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634911_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2353329_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1634944_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635076_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1634944_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635082_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635067_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2411828_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635067_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647319_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635082_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1655603_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635082_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635083_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635083_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353416_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635126_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635193_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635126_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635199_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635184_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635199_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635184_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647303_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635199_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635200_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635200_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353317_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635284_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635355_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635284_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636258_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635294_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635355_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635294_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635361_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635348_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635361_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635348_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647287_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635361_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635362_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635362_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353314_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635626_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635680_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635635_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635680_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635635_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635686_3 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635673_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2353623_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635673_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647174_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635686_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2353623_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635686_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2353626_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635687_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2353626_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635687_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1646841_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1635716_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635759_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635716_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635765_3 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635754_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353629_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635754_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647114_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635765_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353629_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635765_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353632_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635766_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_2353632_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635766_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1646867_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1635795_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635836_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635795_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635842_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635831_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353596_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635831_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647070_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635842_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353596_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635842_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353599_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635843_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2353599_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635843_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1646898_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1635873_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636258_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1635873_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636264_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636253_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353602_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636253_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647043_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636264_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353602_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636264_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353605_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636265_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2353605_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636265_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1646924_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636469_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647596_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636469_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636492_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647467_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1636492_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1636540_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647504_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1636540_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1636564_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648045_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1636564_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1636587_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647538_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1636587_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1636677_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648204_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636677_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636679_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648156_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636679_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1636681_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648116_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1636681_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1636683_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648249_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1636683_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1637366_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1637366_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648005_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1637524_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1637524_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647564_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1637557_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647746_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1637557_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647751_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1637583_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647657_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1637583_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647662_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1637612_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647702_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1637612_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647707_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1637638_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647790_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1637638_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647795_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1637811_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647941_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1637811_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647946_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1637847_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656265_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1637847_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1656270_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1637877_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647855_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1637877_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647860_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1637903_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648016_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1637903_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648021_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
InPort_1648146_2 | SINK | PIPE | HEATING | RIS 7
OutPort_1638386_0 | SOURCE | PIPE | HEATING | RIS 7
InPort_1638386_1 | SINK | PIPE | HEATING | RIS 7
OutPort_1640237_1 | SOURCE | PIPE | HEATING | RIS 7
InPort_1638412_0 | SINK | PIPE | HEATING | RIS 10
OutPort_1648106_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_1640240_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1638412_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_1638438_0 | SINK | PIPE | HEATING | REF 2
OutPort_1647838_2 | SOURCE | PIPE | HEATING | REF 2
InPort_1640230_1 | SINK | PIPE | HEATING | REF 2
OutPort_1638438_1 | SOURCE | PIPE | HEATING | REF 2
InPort_1656249_2 | SINK | PIPE | HEATING | REF 13
OutPort_1638464_0 | SOURCE | PIPE | HEATING | REF 13
InPort_1638464_1 | SINK | PIPE | HEATING | REF 13
OutPort_1640234_1 | SOURCE | PIPE | HEATING | REF 13
Port_1640768_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648701_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640768_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1646841_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640771_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640771_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648774_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640773_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649045_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640773_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640775_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640775_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648806_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640777_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648746_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640777_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640779_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648628_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640779_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640781_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648516_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640781_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640783_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648488_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640783_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640785_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648439_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640785_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640815_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640815_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648668_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640837_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640837_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649005_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640843_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648853_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640843_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648858_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640845_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648898_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640845_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648903_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640847_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649016_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640847_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649021_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640849_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649056_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640849_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649061_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640851_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648711_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640851_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648740_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640853_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648639_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640853_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1648644_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1640855_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648565_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640855_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1648570_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640857_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650072_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640857_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650077_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640859_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650121_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640859_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650126_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640861_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650204_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640861_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1650209_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640863_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650273_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640863_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640865_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1650313_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640865_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640942_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1650056_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640942_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1646867_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1640966_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1648882_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640966_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1646924_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1640978_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1648965_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1640978_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1646898_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_1641095_1 | SINK | PIPE | HEATING | REF 2
OutPort_1648550_0 | SOURCE | PIPE | HEATING | REF 2
InPort_1648596_0 | SINK | PIPE | HEATING | REF 13
OutPort_1641098_1 | SOURCE | PIPE | HEATING | REF 13
InPort_1650189_0 | SINK | PIPE | HEATING | RIS 7
OutPort_1641101_1 | SOURCE | PIPE | HEATING | RIS 7
InPort_1641104_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1650264_0 | SOURCE | PIPE | HEATING | RIS 10
Port_1642146_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649660_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642146_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1647114_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642152_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649719_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642152_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1647174_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642155_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642155_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649281_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642157_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649119_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642157_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642159_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642159_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649313_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642161_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642161_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649345_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642163_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649249_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642163_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642165_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649377_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642165_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642167_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642167_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649447_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642169_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649168_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642169_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642173_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649862_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642173_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642199_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642199_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649217_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642221_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649091_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642221_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642227_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649630_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642227_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649635_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642229_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649540_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642229_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649545_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642231_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649495_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642231_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649500_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642233_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649585_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642233_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649590_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642235_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649735_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642235_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649740_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642237_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649779_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642237_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1649784_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1642239_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649823_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642239_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649828_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642241_0 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649676_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642241_1 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1649681_2 | SOURCEANDSINK | PIPE | HEATING | REF 2
Port_1642243_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649905_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642243_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649910_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642245_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649950_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642245_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649955_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642247_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649989_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642247_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1642350_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1649524_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1642350_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1647043_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_1642479_1 | SINK | PIPE | HEATING | REF 2
OutPort_1649808_0 | SOURCE | PIPE | HEATING | REF 2
InPort_1649764_0 | SINK | PIPE | HEATING | REF 13
OutPort_1642482_1 | SOURCE | PIPE | HEATING | REF 13
InPort_1649935_0 | SINK | PIPE | HEATING | RIS 7
OutPort_1642485_1 | SOURCE | PIPE | HEATING | RIS 7
InPort_1642488_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1649980_0 | SOURCE | PIPE | HEATING | RIS 10
Port_1643810_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1649479_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1643810_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1647070_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_1645337_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1645326_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
