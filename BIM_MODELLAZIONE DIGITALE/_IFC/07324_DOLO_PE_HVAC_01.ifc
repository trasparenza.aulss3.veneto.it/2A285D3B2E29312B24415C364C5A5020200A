Properties of the parts of a building model (IFC4), part 8 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1438238_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1610509_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1463222_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438238_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438238_10 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438254_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438238_11 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438256_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438247_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438248_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438255_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438247_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438249_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438255_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438254_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438249_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438252_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438250_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438250_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438566_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438251_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438252_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438257_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438251_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438253_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438257_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438256_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438253_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438258_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438259_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1610509_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438258_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438258_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438277_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438258_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438279_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438260_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
OutPort_1438327_8 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 8
InPort_1438263_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
OutPort_1438260_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 8
InPort_1438261_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
OutPort_1438263_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 8
InPort_1438264_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1463222_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1463225_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438264_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438283_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438266_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438266_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1463225_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438271_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438269_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438269_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438469_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438270_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438271_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438278_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438270_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438272_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438278_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438277_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438272_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438275_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438273_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438273_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438507_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438274_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438275_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438280_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438274_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438276_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438280_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438279_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438276_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
Port_1438281_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438284_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438281_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1490189_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438282_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438284_3 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438282_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_2406515_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
InPort_1463145_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438283_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
Port_1438284_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438328_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438323_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1646012_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438323_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1646015_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438324_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1645992_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438324_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1645995_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438327_9 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438829_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438327_10 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1645941_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438327_11 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1645921_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438328_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1438829_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
InPort_1438342_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 2
OutPort_1438339_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 2
InPort_1438341_1 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 3
OutPort_1438340_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria esterna 3
InPort_1438339_1 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 2
OutPort_1438342_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 2
InPort_1438467_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1476611_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1439053_0 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 4
OutPort_1438963_1 | SOURCE | DUCT | USERDEFINED | Meccanico Aria esterna 4
InPort_1438963_5 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
OutPort_1438980_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 11
InPort_1438963_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1463697_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1439052_0 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 3
OutPort_1438963_7 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 3
InPort_1439165_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438964_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438964_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1439168_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438965_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1610445_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1464295_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438965_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438965_10 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438973_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438965_11 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438975_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438966_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1439165_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438974_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438966_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438968_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438974_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438973_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438968_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1439139_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438969_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438969_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1439142_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438970_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1439139_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438976_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438970_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438972_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438976_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438975_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438972_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438977_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438978_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1610445_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438977_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438977_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438996_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438977_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438998_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438979_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
OutPort_1439046_8 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 11
InPort_1438982_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
OutPort_1438979_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 11
InPort_1438980_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
OutPort_1438982_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 11
InPort_1438983_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1464295_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1464298_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438983_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1463780_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438985_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438985_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1464298_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1439385_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438988_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438988_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1439388_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438989_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1439385_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438997_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438989_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438991_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438997_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438996_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438991_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1439357_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438992_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438992_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1439360_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438993_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1439357_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438999_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438993_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438995_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438999_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1438998_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1438995_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
Port_1439000_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439003_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439000_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503754_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439001_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439003_3 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439001_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503314_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439003_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439047_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439042_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645522_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439042_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645525_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439043_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645623_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439043_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645626_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439046_9 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439334_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439046_10 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645583_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439046_11 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645516_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439047_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1439334_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
InPort_1439055_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 3
OutPort_1439052_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 3
InPort_1439054_1 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 4
OutPort_1439053_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria esterna 4
InPort_1439052_1 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 3
OutPort_1439055_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 3
InPort_1439910_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1444353_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1464976_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1439910_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1440000_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1440007_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1441704_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1440000_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1440060_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1442939_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1442938_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1440060_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1440109_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1651388_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1442939_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1440109_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1440229_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1464561_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1464564_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1440229_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1441088_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1651917_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1651920_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1441088_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1651388_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1441144_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1441144_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1651609_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1464561_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1441502_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1441502_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1443098_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1441502_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1442938_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1441697_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1441704_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1441816_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1441697_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1441806_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1441816_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1443096_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1441806_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1464481_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1442539_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1442539_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1464564_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1443065_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1443096_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1443098_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1443065_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1443196_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1464481_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_2354821_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
OutPort_1443196_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 19 (1)
InPort_1444083_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1464976_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_2354805_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1444083_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1651141_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1444225_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1444234_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1651141_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1651144_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1444234_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1651208_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1444255_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1444264_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1651208_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1651211_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1444264_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1444353_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1651041_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1444353_3 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1651059_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1599279_0 | SINK | DUCT | EXHAUST | Meccanico Aria esterna 5
OutPort_1444804_1 | SOURCE | DUCT | USERDEFINED | Meccanico Aria esterna 5
InPort_1444804_5 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_2354809_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1444804_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_2354825_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444805_0 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 5
OutPort_1444804_7 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 5
InPort_1444806_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 5
OutPort_1444805_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di scarico 5
InPort_1444805_1 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 5
OutPort_1444806_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 5
InPort_1444808_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1444837_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1465284_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1444808_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1444809_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1465946_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1465949_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444809_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444810_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444824_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444823_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444810_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444811_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1445129_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444824_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444811_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444812_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1465643_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1465646_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444812_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1445129_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444814_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444814_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1445132_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1465643_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444816_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444816_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1465761_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444816_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444823_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444820_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444817_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444817_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1465949_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444819_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444820_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1465758_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444819_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1465325_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444821_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444821_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1465646_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444825_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1465758_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1465761_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444825_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444828_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1465325_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_2354825_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 17
OutPort_1444828_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 17
InPort_1444833_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1651025_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1651028_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1444833_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1444834_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1650973_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1650976_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1444834_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1444837_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1650989_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1444837_3 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1650936_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_2354807_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1445945_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1445945_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1466025_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_2354823_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1445981_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1445981_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1657655_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1446402_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1851135_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1466025_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1446402_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1446935_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1453771_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1453870_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1446935_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1446944_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1453870_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1657829_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1446944_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1446987_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1657837_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1657655_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1446987_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1657837_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1447701_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1447701_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 22
OutPort_1657839_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 22
InPort_1448540_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1654593_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1654911_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1448540_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_2427119_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1448553_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1448553_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1655098_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1448610_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1448628_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1448628_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1448623_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1448623_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1655187_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1448653_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1772857_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1773186_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1448653_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1475431_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1448712_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1448712_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1475434_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1628525_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1448860_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1448860_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1645320_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1450531_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2470238_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2470240_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1450531_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1452706_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1851132_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1851135_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1452706_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1592475_0 | SINK | DUCT | EXHAUST | Meccanico Aria di scarico 4
OutPort_1454064_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 4
InPort_1593167_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1454064_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1454064_4 | SINK | DUCT | EXHAUST | Meccanico Aria di ritorno 1
OutPort_1593041_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1454064_5 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 1
OutPort_1592797_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria di mandata 1
InPort_1645320_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1454474_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1454474_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1645337_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1628656_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1454474_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1457080_1 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 7
OutPort_1592797_0 | SOURCE | DUCT | EXHAUST | Meccanico Aria esterna 7
InPort_1457176_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1475431_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2465877_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1457176_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1457254_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2465877_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2465879_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1457254_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1457826_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1867175_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1868228_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1457826_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1457987_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1868228_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1868230_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1457987_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1457987_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1629471_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1458216_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2470240_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1867175_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1458216_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1628599_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1459031_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1459031_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1628658_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1463342_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1463464_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1463697_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1463780_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1465217_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1465284_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_2354809_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1465217_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1466595_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1466309_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1466949_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1466958_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1580066_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1466949_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1467264_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864175_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1467353_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2435027_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1834895_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1467353_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1467481_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1834895_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1835064_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1467481_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1472167_0 | SINK | DUCT | EXHAUST | Meccanico Aria esterna 8
OutPort_1427368_5 | SOURCE | DUCT | VENTILATION | Meccanico Aria esterna 8
InPort_1475102_1 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 8
OutPort_1472167_1 | SOURCE | DUCT | EXHAUST | Meccanico Aria esterna 8
InPort_1655187_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1472703_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1472703_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1655189_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1473265_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1869451_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1869453_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1473265_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1655189_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1473295_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1473413_0 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_2409125_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_2409126_2 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_1473413_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_1869451_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1473666_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1473666_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1654841_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1473678_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1773186_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1773189_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1473678_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1610176_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1473823_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1610174_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1474078_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1474078_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1610176_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1474086_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1610174_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1474158_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1474086_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1475131_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1474612_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1475078_1 | SINK | DUCT | VENTILATION | Meccanico Aria esterna 9
OutPort_1590544_0 | SOURCE | DUCT | EXHAUST | Meccanico Aria esterna 9
InPort_1609426_0 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1475131_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1609531_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 11
OutPort_1475185_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 11
InPort_1634351_1 | SINK | DUCT | VENTILATION | Meccanico Aria di scarico 9
OutPort_1475221_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di scarico 9
InPort_2427118_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1475260_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1475260_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_2427119_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1475434_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850533_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1476609_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1502041_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1476611_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1476609_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
Port_1483356_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1486798_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1483356_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1510191_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1486798_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1486810_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1486997_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1595407_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1486997_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1846681_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1495919_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1498999_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1495919_3 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500551_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
InPort_1495919_4 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 5
OutPort_1495978_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 5
Port_1495931_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500525_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1495931_3 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1498925_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
InPort_1495931_4 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 4
OutPort_1496036_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 4
Port_1498925_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500466_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1498999_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499370_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500525_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500653_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500551_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1501015_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500786_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500936_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500786_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1501015_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500800_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500936_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500800_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500862_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
InPort_1502041_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1502264_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1502264_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1502050_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
Port_1502352_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502551_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502352_3 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502525_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
InPort_1502352_4 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 15
OutPort_1502397_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 15
Port_1502374_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502599_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502374_3 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502575_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
InPort_1502374_4 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 18
OutPort_1502482_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 18
Port_1502525_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502963_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502551_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503919_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502575_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503616_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502599_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503109_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
InPort_1505041_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1505057_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1505057_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1505050_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1505050_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1505073_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1506924_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1915874_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1506940_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1506929_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1506929_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1506944_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1507033_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1507024_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1507024_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1507036_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1509062_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1509024_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1509061_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1509062_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1509075_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1509061_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1510088_4 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 14
OutPort_1509162_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 14
InPort_1509322_4 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 13
OutPort_1509205_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 13
Port_1509322_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1509959_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1509322_3 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1509871_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1509871_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1509902_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1509959_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1510007_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1510088_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1595407_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1510088_3 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1510191_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
InPort_1511374_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1511177_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1511280_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1511352_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
Port_1511978_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1608851_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_1511978_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2001872_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_1512071_0 | SINK | PIPE | HEATING | REF 2
OutPort_2001729_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2001130_1 | SINK | PIPE | HEATING | REF 2
OutPort_1512071_1 | SOURCE | PIPE | HEATING | REF 2
InPort_1512100_0 | SINK | PIPE | HEATING | RIS 10
OutPort_1608211_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2001914_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1512100_1 | SOURCE | PIPE | HEATING | RIS 10
Port_1512113_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1608493_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1512113_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2002282_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_1512307_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1608669_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2013417_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1512307_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1512309_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1608644_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1512309_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014764_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1574635_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1512420_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1512420_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936641_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1512457_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1574598_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1512457_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936656_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1608669_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1512599_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1512599_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2032709_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1512707_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1608644_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1512707_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2032703_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1512982_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936879_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1888174_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1512982_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936877_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1513021_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1513021_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1888135_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1525843_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1513161_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1513161_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1527058_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1525841_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1513163_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1513163_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1888182_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542334_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1513179_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1513179_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1541555_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1541758_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1513293_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1513293_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937019_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1525841_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1527058_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1525841_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1525841_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1527271_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936980_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1525843_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1527271_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542345_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1541555_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1541760_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1541760_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1541758_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542332_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542334_3 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542345_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542332_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542335_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542334_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1888143_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542335_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936751_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542597_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542597_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1578422_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542627_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936753_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1578379_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542627_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936791_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542691_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542691_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936793_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542713_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542694_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542694_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936818_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936795_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1542696_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1542696_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936731_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1542698_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1936759_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542698_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542698_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936761_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542698_4 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936763_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936793_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542699_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1542699_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936759_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936761_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1542703_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
