Properties of the parts of a building model (IFC4), part 2 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1176704_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176703_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176703_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176707_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2420999_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176716_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176716_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2421000_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1190296_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176744_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176744_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1506132_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1506132_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1176745_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176745_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1178495_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1176745_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1178494_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1179075_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1176753_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1176753_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2420999_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179189_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179511_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179805_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1179190_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1188230_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179207_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179207_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1188233_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1180727_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179231_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179231_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1187955_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179511_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179736_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179736_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179582_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179582_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179738_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179728_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1188230_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1179738_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1179728_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1506393_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1179805_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1506392_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1180060_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1180060_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1506393_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1180201_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180206_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1180636_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180201_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1180203_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180636_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1180637_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180203_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1180206_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180729_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1180253_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1506392_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1180688_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1180253_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1180255_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1180712_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1788187_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1180255_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1188233_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180405_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1180405_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180637_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1180405_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971690_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971692_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1180405_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1180714_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1180688_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1180712_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1180714_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1180729_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180727_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1183152_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180859_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1788790_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1180859_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1181128_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1791654_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1181238_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1788790_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1791647_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1181238_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1788682_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1181238_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1181384_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1784873_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1181395_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1915448_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1790482_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1181395_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1790480_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1181396_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1181396_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1790482_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1187443_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1182652_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1182652_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1802204_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1802204_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1183152_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1239513_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1183381_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183382_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1896796_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1787084_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1183419_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183419_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1795461_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183419_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1795602_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183631_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1183630_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1505073_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1183631_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183635_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1183677_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183670_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1183635_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183677_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1183637_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183637_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1183640_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1183640_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1505041_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1206566_4 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1183670_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1827932_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1184036_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1827617_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1184718_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1184718_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1827959_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1184759_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1185103_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1185104_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1184759_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1795606_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1184793_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1184793_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1185104_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1184806_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1795606_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1795602_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1184806_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829183_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1185174_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1185928_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797553_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1187063_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1796898_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1797308_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1187063_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1187080_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1828016_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434744_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1187080_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829302_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1187144_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1187144_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1187148_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1187148_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829195_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1797643_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1187168_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1187168_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1797026_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1791291_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1187443_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1187515_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1187443_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2421000_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1187515_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1187955_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1789013_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1188542_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1187955_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1788946_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1188542_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1828867_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1188598_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1828176_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1188609_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1188609_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1828179_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1188610_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1828874_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1828179_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1188610_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1188639_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1827179_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1188647_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1874393_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1874919_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1188647_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1915521_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1188947_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1188947_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1915036_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1188947_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971402_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971404_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1188947_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1189803_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1189649_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1189649_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1189815_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1189748_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1189803_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1189777_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1189748_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1795461_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1189762_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1189762_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1189777_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1189815_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1189808_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1189808_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1788248_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1788248_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1189820_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1189820_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1788251_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1189820_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190165_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1788251_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190041_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190041_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1787977_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190041_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1787886_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190203_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190085_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190085_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190217_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190141_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190203_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190166_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190141_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190165_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190155_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190155_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190166_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190217_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190208_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190208_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190297_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190494_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1190495_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1190495_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1192885_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1192885_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1190501_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1190501_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1192805_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1190533_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190532_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1193349_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190533_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1190540_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193349_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1193347_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1190540_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1191095_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1191096_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1191096_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1191105_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1191105_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1191099_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1191099_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1192805_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1191101_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1191100_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1193384_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1191101_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1191104_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193384_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1193382_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1191104_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1787977_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1191631_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1191631_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1788178_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1193434_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1191807_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1191807_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193358_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1191807_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193347_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1191807_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193382_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1192805_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1193038_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193018_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1556401_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1556402_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1193018_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193028_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1556423_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193048_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1193028_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193038_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1193048_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1556401_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1193069_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193069_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1788882_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1788882_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1193071_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193071_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1788946_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1556425_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1193153_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193153_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1556402_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193153_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1971599_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1971601_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1193153_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1556423_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1193306_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193306_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1556425_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1193430_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193434_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1193433_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193430_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1787886_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193432_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1193432_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193433_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1193609_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829302_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829380_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1193609_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1195539_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1195540_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1195540_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1877367_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1195547_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1799905_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1799952_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1195547_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1799951_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1195554_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1195554_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1799952_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1798939_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1195556_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1195556_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1799951_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1195556_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972672_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972677_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1195556_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1195832_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1196699_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1799905_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1195832_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1196699_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1196743_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1200663_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1196699_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1196743_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1803058_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1197222_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1572027_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1572028_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1197222_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209476_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1197335_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1197335_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1806467_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1197715_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1197714_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1199188_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1197715_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1197740_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1197741_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1197741_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1198278_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1198278_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1198292_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1198292_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199917_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199917_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1198302_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1198302_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199919_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1198366_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2470904_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1199312_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1198366_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1199316_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1198707_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1198707_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1198711_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1198709_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1199188_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1198711_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1198709_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1199036_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199037_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199037_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199097_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199097_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199345_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1206566_5 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1199312_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2470766_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1199316_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1199345_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199359_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199384_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199352_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199352_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199996_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199359_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199389_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199637_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199384_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199919_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199384_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199389_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199637_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199939_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199940_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199940_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1892410_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1199996_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1201269_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1892381_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1199996_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1200137_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1200138_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1200138_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1876947_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1200142_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1800366_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1800377_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1200142_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1200441_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1572028_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1800366_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1200441_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1200441_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972016_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972018_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1200441_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1572027_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1200661_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1200661_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1799802_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1799802_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1200663_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1201197_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1892381_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1892393_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1201197_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1201267_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209369_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1201539_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1201267_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1201269_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1511374_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1511177_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1201359_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1201359_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1511280_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1201359_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972161_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972163_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1201359_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1511352_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1201539_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1201655_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1201654_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1203134_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1201655_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1201676_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1201675_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202384_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1201676_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1201679_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202384_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202397_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1201679_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202317_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1201909_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1201909_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202396_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202191_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202194_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202194_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1802729_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1802729_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202202_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202202_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1892863_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202202_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1892790_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202318_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202293_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202293_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202317_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202396_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202386_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202386_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202397_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202780_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203134_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1203135_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202780_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1202781_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203135_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1203459_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1202781_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1203168_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203459_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1892792_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203168_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1203176_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1892792_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1892790_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203176_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209920_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203315_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1203315_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205340_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1203315_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204092_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1203315_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204099_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204696_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203810_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204691_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203821_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204745_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203830_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204467_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203839_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204952_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203848_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205053_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203857_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205141_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203864_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205241_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1203873_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204092_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204527_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204099_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204094_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204094_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204610_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204160_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1209884_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1206827_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204160_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204189_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204182_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204182_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204338_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204182_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204289_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204182_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204315_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204182_4 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204358_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209881_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204189_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209881_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204211_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204211_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204901_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209881_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204228_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204258_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204253_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204253_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204267_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204901_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204258_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204267_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204260_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204260_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205004_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204289_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204709_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204315_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204306_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204306_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204588_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204358_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204353_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204353_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204501_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204515_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204467_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204559_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204470_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204501_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204494_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204494_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204515_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204527_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204543_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204543_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204536_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204536_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204559_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204588_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204581_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204581_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204694_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204610_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204603_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204603_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204699_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204694_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204691_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204699_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204696_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204709_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204724_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204724_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204717_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204717_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204748_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204748_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204745_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204901_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204917_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204917_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204910_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204910_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204962_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204962_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204952_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205004_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1204997_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1204997_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205056_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205056_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205053_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205078_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205338_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205340_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205078_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205078_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205189_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205338_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205087_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205087_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205119_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205119_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205110_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205110_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205144_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205144_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205141_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205189_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205208_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205208_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205224_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205224_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205217_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205217_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205244_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205244_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205241_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1205376_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205381_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1218414_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1205376_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1792306_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1206566_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1206566_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1787084_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1206566_7 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1826503_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1218130_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1206827_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1206913_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1804579_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1803330_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1206913_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1807022_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1206913_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1206990_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1208561_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1208559_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1206990_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1206992_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1206993_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1206993_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1206995_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1206995_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1206997_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1206997_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1207000_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1206999_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1208559_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1207000_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1206999_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1206999_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972283_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972285_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1206999_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1208561_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1207006_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1207006_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1208694_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1208694_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1207903_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1207903_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1807265_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434095_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1209231_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209231_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1209233_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209233_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1218416_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209233_5 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1218158_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209367_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228292_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209369_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209367_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209478_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209476_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1210721_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209478_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209682_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209683_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209683_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1890387_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1212717_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209688_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209688_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1213855_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1213855_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209689_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209689_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1815027_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209695_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1212717_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1212720_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209695_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209698_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209697_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209697_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1212720_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209697_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975109_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975111_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1209697_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1890130_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1209698_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1209884_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1209879_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209879_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1209883_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209883_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1209881_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209915_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1209920_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1892862_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1209915_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1209917_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1892862_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1892863_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1209917_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1807549_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1210721_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1215327_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1210721_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
