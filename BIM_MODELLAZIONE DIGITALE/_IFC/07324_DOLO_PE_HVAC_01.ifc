Properties of the parts of a building model (IFC4), part 3 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1211045_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1210726_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1210726_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1807549_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1804579_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1211045_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1807713_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1211045_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1815027_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1213752_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1213752_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1815032_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1213905_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1890410_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1890413_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1213905_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1890387_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1213914_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1213914_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1890413_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214028_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1214027_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1504256_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1214028_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1214815_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1215078_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1215076_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1214815_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214817_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1214818_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214818_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1214820_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214820_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1214822_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214822_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1214825_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214824_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1215076_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214825_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1214824_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214824_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975256_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975258_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1214824_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1215078_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1214831_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214831_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1889575_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1889575_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1214832_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1214832_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1889576_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1504254_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1215164_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1215164_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1504256_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1215201_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1217886_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1217068_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1215201_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1218158_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1215203_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1215203_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1217068_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1889576_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1215327_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1215618_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1215617_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1217548_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1215618_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1216579_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1217533_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1217243_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1216579_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1217734_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1217243_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1217533_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1217524_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1217524_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1217548_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1217886_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1217734_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1217734_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1504254_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1218130_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1218414_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1218416_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1218130_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1771565_4 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1219079_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1219079_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1228253_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1825145_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1220467_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1220477_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1220472_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1220472_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1220511_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1824918_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1220477_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1220511_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1825395_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1823580_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1220830_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1220830_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1774314_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1823710_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1221065_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1221106_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_2434116_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1221111_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1221106_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1223219_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1221106_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1806467_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1221111_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1221655_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1775648_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1225351_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1221655_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222135_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222155_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222153_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222135_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222136_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1825044_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222141_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222144_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1886595_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222141_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222144_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222143_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222143_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222153_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222143_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937323_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937325_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1222143_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1222155_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222146_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222146_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1822887_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1822887_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222149_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222149_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1823356_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222757_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1823998_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1886110_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222757_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222758_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222759_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222759_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1823905_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1823905_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222763_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222763_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1886112_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222765_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1886110_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1886112_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222765_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222765_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1975208_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1975210_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1222765_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1823998_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1222768_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1222768_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1824054_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1824056_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1223219_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1224645_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2436740_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2436739_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1224645_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1809129_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1225351_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1227009_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1225351_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1228410_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1225427_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1225427_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1225451_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1225451_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228502_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226263_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1226264_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226264_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1226270_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226270_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1226267_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226267_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1226351_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226312_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1226313_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226313_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1226318_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226318_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1226316_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226316_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1226351_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226351_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228029_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1227709_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1226896_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1226896_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1227040_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1227040_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1227009_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1227703_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1227709_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1774577_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1227703_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1774580_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1227705_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1227705_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1774577_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1228162_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1227900_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1227900_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1774580_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1227900_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937091_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937093_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1227900_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1228029_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228162_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1228253_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2434093_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1228253_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2436739_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1228292_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1823357_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1228383_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228412_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1229815_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228383_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1229352_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228383_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1228385_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1775646_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1775648_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228385_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1228412_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228410_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1229600_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228410_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1228500_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231479_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1228502_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1228500_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230196_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1229280_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1229280_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230560_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1229374_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1229352_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1320128_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1229374_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1229555_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1320057_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1320059_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1229555_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1320057_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1229600_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1775646_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1229815_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230023_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1232134_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230045_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1232129_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230056_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1232125_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230089_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233261_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1233418_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230089_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231175_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230196_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231322_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230196_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230265_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230236_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230236_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230268_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230413_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230265_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230268_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1320151_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230296_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230530_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230560_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230296_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230296_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936877_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936879_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1230296_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1230530_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230413_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230759_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231170_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231231_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230759_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1230791_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231231_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1236753_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1230791_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231170_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231175_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231350_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231170_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231313_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231322_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231332_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231313_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231325_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231332_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1883787_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231325_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1236708_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231350_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231479_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1231497_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231497_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1448610_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1231611_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1771559_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1231613_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1231611_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1772857_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1231613_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1232125_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1236753_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232129_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1236708_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232134_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1883787_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232349_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1232350_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232350_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233560_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1233477_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1232354_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232354_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233415_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232355_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233477_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1233518_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1232355_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1233560_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1232356_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232356_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1542506_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1542506_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1232359_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232359_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233578_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232359_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936751_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936753_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1232359_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1233578_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1232362_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232362_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233518_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1232624_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1232623_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1319271_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1232624_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1232627_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1319281_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1319283_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1232627_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1232631_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233242_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1319245_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1232631_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1319281_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1232635_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1232635_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1319271_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233148_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1319245_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1319243_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233148_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233242_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233237_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233237_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233241_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233239_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1319283_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233241_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233239_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233261_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233256_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1233256_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1319821_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1319821_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233258_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1233258_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1320050_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1233415_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233363_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1233363_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1233418_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1233756_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233749_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1234905_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233756_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233824_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235067_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233839_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233824_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233824_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1234930_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233834_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235392_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1234135_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233834_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1233834_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1319243_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775963_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1233839_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1234128_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1234135_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1773459_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1234128_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1234930_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1234905_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1235262_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1773459_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1773457_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235262_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1235364_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775966_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1235392_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235364_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1235611_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235610_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237101_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235611_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1235661_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237405_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775919_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235661_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1235661_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237490_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1235661_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237536_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1235663_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1775880_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1773416_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235663_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237618_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235890_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1235890_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238167_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237839_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235924_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238181_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1235936_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1236511_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237600_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237490_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1236511_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237600_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237047_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237047_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237101_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237536_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237533_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237533_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237618_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237533_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237723_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237723_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237716_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237716_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237842_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1237842_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1237839_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238167_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238160_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238160_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238184_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238184_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238181_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238395_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238394_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238597_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238395_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238398_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238597_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238595_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238398_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238418_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238417_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238619_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238418_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238421_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238619_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238617_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238421_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1776035_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238486_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238486_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238535_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238486_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238595_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238486_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238617_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1238505_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1776003_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1775002_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1238505_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1239134_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1897289_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1897723_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239134_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1335556_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239157_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1239157_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1335557_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1239228_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239958_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1239233_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239228_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1897296_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239228_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1897289_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239233_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1240371_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1239507_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1239665_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1239513_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1239620_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1239665_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1239635_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1239620_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1239628_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1240444_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1311761_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1239628_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1239786_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1239635_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1239832_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1239786_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1240441_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1239832_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1239834_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1311761_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1335250_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1239834_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1239858_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1335556_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1239861_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239858_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1564176_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239860_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1239860_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239861_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1896885_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1239894_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1239894_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1564176_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1239894_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922967_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922969_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1239894_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1239958_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1896885_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1240373_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1240272_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1240272_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1240371_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1240441_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1240373_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1240444_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1240439_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1240439_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1240443_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1240443_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1240441_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1240720_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1241640_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1240722_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1241637_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1848799_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1240767_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1240767_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1243613_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1240905_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1848970_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1241079_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1240905_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1240950_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1241074_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1241016_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1240950_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1241009_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1241016_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1848599_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1241009_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1241074_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1241079_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1241487_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1241074_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1848602_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1241487_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1241637_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1848599_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1241640_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1848602_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1243638_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1243606_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1243606_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849213_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1243613_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1243643_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1848616_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1243638_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849513_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1243638_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1243643_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1848616_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1243910_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1848799_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1848981_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1243910_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1244118_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849268_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849213_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1244118_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1244118_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1921271_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1921273_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1244118_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1336007_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1244178_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1244178_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1335959_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1245891_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1244219_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1245900_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1244220_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1245894_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1244246_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1245897_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1244247_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1244281_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246026_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1244296_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1244281_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1864108_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1244296_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246028_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1244313_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1848300_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1245712_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1245712_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1848306_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1245848_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849738_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849735_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1245848_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1245857_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849760_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849758_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1245857_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1848302_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1245868_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1245868_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1848303_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849738_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1245891_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849760_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1245894_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1848303_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1245897_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1848306_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1245900_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246026_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246028_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246028_6 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1848300_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246028_7 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1848302_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246105_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246106_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246106_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246111_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246111_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246720_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246131_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246130_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246656_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246131_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246133_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246829_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1632710_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246133_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1249015_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246656_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246659_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1632710_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1632712_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246659_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246720_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246736_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246851_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246729_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246729_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246743_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246736_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1248996_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246743_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1248399_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246829_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246824_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246824_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246828_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246826_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1249018_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246828_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1246826_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1246846_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246851_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246850_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246846_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1248999_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246848_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1246848_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1246850_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247036_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1832939_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247952_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1247040_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247040_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1248394_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247067_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247065_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247066_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247072_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247073_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247066_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247072_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247067_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247082_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247069_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247069_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247071_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247071_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247070_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247070_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247073_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247080_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247082_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247085_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247080_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247973_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247085_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247086_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247971_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1833423_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247086_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1247839_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1247871_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1832939_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1247839_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247869_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1247875_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247874_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1247869_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247871_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1247874_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247875_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1247954_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247954_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1247952_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1247971_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1247973_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1248394_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1249932_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1248399_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1248394_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
