Properties of the parts of a building model (IFC4), part 14 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1910904_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1910897_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1912190_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1912183_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1914479_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1914469_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1914785_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1914801_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1914801_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1914794_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1914794_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1914836_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434607_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1915034_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1915459_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1915450_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1915450_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1915545_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1915545_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1915463_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1916131_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1916211_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1916182_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1916191_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1916199_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1916182_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1916194_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1916199_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1916211_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1916194_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1916550_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1916548_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1916548_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1916560_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1916550_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1916551_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1916582_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1916584_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1916594_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1916582_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1916585_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1916584_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1916642_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1916649_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1916666_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1916642_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1918024_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918022_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918022_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918036_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918025_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918024_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1918069_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1918258_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1918258_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1918259_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1918398_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1918376_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1918387_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1918398_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1918418_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1918387_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1918414_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1918401_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1918401_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1918418_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1918412_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1918410_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1918410_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1918414_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1918446_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918436_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918436_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918466_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918449_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918462_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918466_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918449_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918458_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918460_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918462_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918458_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1919811_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1919824_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1919818_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1919819_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1919819_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928529_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1919824_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920056_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1928252_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920230_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1920280_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928233_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922900_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1921460_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1921460_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936030_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928488_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922055_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922055_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1928252_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922416_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928452_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928233_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922416_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922527_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922525_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922525_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922539_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922527_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922528_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922528_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1935686_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922560_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922562_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922574_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922560_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922563_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922562_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1935740_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922563_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922866_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922864_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922864_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922878_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922867_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922866_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936028_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922867_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1922898_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922900_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922915_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922898_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1922901_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922900_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1935852_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1922901_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928453_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928231_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928250_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1928489_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1928450_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928452_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928466_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928450_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928452_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1928453_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1928488_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1928486_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1928486_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1928500_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1928489_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1928488_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1935676_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1935678_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1935688_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1935676_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1935734_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1935732_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1935732_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1935742_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936332_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936359_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936352_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936358_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936352_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936415_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936358_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936359_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936641_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936685_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1936656_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936722_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936684_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936682_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936682_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936696_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936685_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936684_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936684_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936981_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936719_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936721_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936733_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936719_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936721_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936722_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936721_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937006_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936981_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936980_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937003_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937005_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937019_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937003_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937005_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937006_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937192_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937236_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937213_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937271_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937233_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937235_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937247_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937233_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937235_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937236_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937270_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937268_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937268_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937284_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937271_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937270_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1937442_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937519_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937483_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937481_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937481_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937493_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937483_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937484_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937516_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937518_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937530_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937516_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937518_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937519_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972651_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972617_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972640_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972653_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973068_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973102_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973104_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973091_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973357_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973359_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973371_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973357_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973988_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973359_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973360_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973987_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973610_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973360_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973502_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973500_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973500_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973518_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973502_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974165_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974164_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973503_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973503_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973588_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1973985_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973987_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974001_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973985_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973987_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1973988_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974099_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974097_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974097_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974109_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974164_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974162_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974162_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974179_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974165_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974164_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974232_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974234_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1974242_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1974232_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1997847_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2001914_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2002130_1 | SINK | PIPE | HEATING | RIS 10
OutPort_1997847_1 | SOURCE | PIPE | HEATING | RIS 10
Port_1999004_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2122409_0 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_1999004_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158366_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1999004_3 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2122535_0 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_1999004_4 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2122566_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_1999970_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2002282_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1999970_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2002288_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1999994_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2001257_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_1999994_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2002288_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000005_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2002631_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000005_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000088_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000032_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2001872_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2000032_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002072_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2000080_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000088_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000080_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000166_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000166_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2113525_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000171_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2003356_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2000171_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2157042_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_2000486_1 | SINK | PIPE | HEATING | REF 9
OutPort_2107255_0 | SOURCE | PIPE | HEATING | REF 9
InPort_2000488_1 | SINK | PIPE | HEATING | REF 9
OutPort_2107245_1 | SOURCE | PIPE | HEATING | REF 9
InPort_2002418_0 | SINK | PIPE | HEATING | REF 2
OutPort_2001130_2 | SOURCE | PIPE | HEATING | REF 2
Port_2001251_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2001257_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2001251_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2002628_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2001260_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2002628_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2001260_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2002631_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_2001778_1 | SINK | PIPE | HEATING | REF 2
OutPort_2001739_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2001739_1 | SINK | PIPE | HEATING | REF 2
OutPort_2001782_2 | SOURCE | PIPE | HEATING | REF 2
Port_2002072_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002383_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2002348_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2002130_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2002364_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2002348_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2002467_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2002364_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2002383_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002399_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002399_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002509_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2002434_2 | SINK | PIPE | HEATING | REF 2
OutPort_2002418_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2002549_0 | SINK | PIPE | HEATING | REF 2
OutPort_2002434_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2002487_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2002467_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2002479_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2002487_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2002759_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2002479_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2002509_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002530_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002530_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002787_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2002567_2 | SINK | PIPE | HEATING | REF 2
OutPort_2002549_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2002559_0 | SINK | PIPE | HEATING | REF 2
OutPort_2002567_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2002830_2 | SINK | PIPE | HEATING | REF 2
OutPort_2002559_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2002749_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2002759_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2002912_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2002749_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2002787_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002803_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002797_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002803_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002797_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002938_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2002822_0 | SINK | PIPE | HEATING | REF 2
OutPort_2002830_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2003003_1 | SINK | PIPE | HEATING | REF 2
OutPort_2002822_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2002904_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2002912_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2003110_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2002904_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2002930_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002938_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2002930_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2003150_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2002995_0 | SINK | PIPE | HEATING | REF 2
OutPort_2003003_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2003052_1 | SINK | PIPE | HEATING | REF 2
OutPort_2002995_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2113423_0 | SINK | PIPE | HEATING | REF 2
OutPort_2003052_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2144333_2 | SINK | PIPE | HEATING | REF 2
OutPort_2003073_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2003073_1 | SINK | PIPE | HEATING | REF 2
OutPort_2144336_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2113469_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2003110_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2156992_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2003115_0 | SOURCE | PIPE | HEATING | RIS 10
InPort_2003115_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2156995_2 | SOURCE | PIPE | HEATING | RIS 10
Port_2003150_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2113377_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2003155_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2156936_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2003155_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2156939_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2003200_0 | SINK | PIPE | HEATING | REF 2
OutPort_2144333_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2129537_2 | SINK | PIPE | HEATING | REF 2
OutPort_2003200_1 | SOURCE | PIPE | HEATING | REF 2
Port_2003259_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2156936_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2003259_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2129585_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2003297_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2156992_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2119730_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2003297_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2003356_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2119791_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_2106617_1 | SINK | PIPE | HEATING | REF 2
OutPort_2003494_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2003494_1 | SINK | PIPE | HEATING | REF 2
OutPort_2108053_3 | SOURCE | PIPE | HEATING | REF 2
InPort_2012884_0 | SINK | PIPE | HEATING | REF 9
OutPort_2106556_2 | SOURCE | PIPE | HEATING | REF 9
InPort_2107294_3 | SINK | PIPE | HEATING | REF 9
OutPort_2012884_1 | SOURCE | PIPE | HEATING | REF 9
InPort_2106599_1 | SINK | PIPE | HEATING | REF 2
OutPort_2012918_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2012918_1 | SINK | PIPE | HEATING | REF 2
OutPort_2108022_3 | SOURCE | PIPE | HEATING | REF 2
Port_2013347_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014764_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2013347_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014827_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2013374_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2013417_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2014442_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2013374_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2013510_0 | SINK | PIPE | USERDEFINED | Altro 2
OutPort_2145611_1 | SOURCE | PIPE | HEATING | Altro 2
Port_2013510_1 | SOURCEANDSINK | PIPE | USERDEFINED | Altro 2
InPort_2013561_0 | SINK | PIPE | USERDEFINED | Altro 3
OutPort_2145659_1 | SOURCE | PIPE | HEATING | Altro 3
Port_2013561_1 | SOURCEANDSINK | PIPE | USERDEFINED | Altro 3
InPort_2013604_0 | SINK | PIPE | USERDEFINED | Altro 4
OutPort_2145749_1 | SOURCE | PIPE | HEATING | Altro 4
Port_2013604_1 | SOURCEANDSINK | PIPE | USERDEFINED | Altro 4
InPort_2013647_0 | SINK | PIPE | USERDEFINED | Altro 5
OutPort_2145703_1 | SOURCE | PIPE | HEATING | Altro 5
Port_2013647_1 | SOURCEANDSINK | PIPE | USERDEFINED | Altro 5
InPort_2013886_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2082527_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2082327_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2013886_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2013886_3 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_2013923_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2058303_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2013925_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2015929_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2058302_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2013932_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2013932_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057884_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2013937_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057140_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2047629_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2013937_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2014434_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2014442_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2014452_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2014434_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2014446_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2014452_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2014463_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2014446_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2014455_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2014463_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2014474_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2014455_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2014466_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2014474_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2015214_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2014466_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_2014501_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014824_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014501_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014827_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014514_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014824_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014514_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014531_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014523_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014531_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014523_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014540_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014534_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014540_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2014534_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015259_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2015206_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2015214_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2015223_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2015206_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2113605_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2015223_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_2015249_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015259_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015249_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015268_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015268_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2113657_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015294_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2158565_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015294_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015443_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2015387_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2158597_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2015404_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2015387_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2119665_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2015404_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_2015435_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015443_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2015435_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2119628_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2015929_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2049756_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2031787_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2049826_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2031814_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2031787_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2031816_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057922_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2032370_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2033205_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2049756_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2032370_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2033205_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2047607_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2047605_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2082327_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2047607_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2047605_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2082527_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2047629_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2049756_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121137_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2049826_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057845_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057142_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2049826_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057140_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057142_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057588_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057921_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057893_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057588_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057845_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2058452_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057882_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057893_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057888_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057882_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057884_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057886_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057885_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057960_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057886_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057885_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057889_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057888_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2082857_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057889_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057921_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2058453_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057922_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2057921_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2057960_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2082857_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2058302_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121171_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2058303_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2058302_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2058422_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2121170_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2121176_3 | SINK | PIPE | HEATING | RIS 10
OutPort_2058422_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2058444_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2058444_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121086_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2058453_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2058452_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2058452_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_2161348_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2082857_3 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_2082943_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2112511_0 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082945_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2082951_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082951_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2112540_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082953_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2082976_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082955_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2082953_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082957_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2110237_0 | SOURCE | PIPE | HEATING | RIS 10
InPort_2112379_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2082968_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082968_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2443915_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2112540_3 | SINK | PIPE | HEATING | RIS 10
OutPort_2082969_0 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082969_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2112448_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082971_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2082981_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2083044_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2082971_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082976_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2083000_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2110709_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2082976_3 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082981_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2110622_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082983_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2110277_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082995_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2082983_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2112339_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2082992_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082992_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2443708_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2112510_3 | SINK | PIPE | HEATING | RIS 10
OutPort_2082993_0 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082993_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2112447_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2082996_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2082995_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2443393_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2082996_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2083000_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2120979_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2083023_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2119289_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2083023_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2119295_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_2120979_3 | SINK | PIPE | HEATING | RIS 10
OutPort_2083031_0 | SOURCE | PIPE | HEATING | RIS 10
InPort_2083031_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2120999_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2443370_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2083044_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2094748_0 | SINK | PIPE | HEATING | REF 9
OutPort_2106577_2 | SOURCE | PIPE | HEATING | REF 9
InPort_2107254_3 | SINK | PIPE | HEATING | REF 9
OutPort_2094748_1 | SOURCE | PIPE | HEATING | REF 9
InPort_2106556_1 | SINK | PIPE | HEATING | REF 9
OutPort_2106558_1 | SOURCE | PIPE | HEATING | REF 9
InPort_2106558_0 | SINK | PIPE | HEATING | REF 9
OutPort_2107497_2 | SOURCE | PIPE | HEATING | REF 9
InPort_2106577_1 | SINK | PIPE | HEATING | REF 9
OutPort_2106579_1 | SOURCE | PIPE | HEATING | REF 9
InPort_2106579_0 | SINK | PIPE | HEATING | REF 9
OutPort_2107456_2 | SOURCE | PIPE | HEATING | REF 9
InPort_2106601_1 | SINK | PIPE | HEATING | REF 2
OutPort_2106599_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2129051_1 | SINK | PIPE | HEATING | REF 2
OutPort_2106601_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2106619_0 | SINK | PIPE | HEATING | REF 2
OutPort_2106617_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2128865_1 | SINK | PIPE | HEATING | REF 2
OutPort_2106619_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2107245_0 | SINK | PIPE | HEATING | REF 9
OutPort_2107294_2 | SOURCE | PIPE | HEATING | REF 9
Port_2107254_1 | SOURCEANDSINK | PIPE | HEATING | REF 9
Port_2141762_1 | SOURCEANDSINK | PIPE | HEATING | REF 9
InPort_2107255_1 | SINK | PIPE | HEATING | REF 9
OutPort_2107254_2 | SOURCE | PIPE | HEATING | REF 9
Port_2107294_1 | SOURCEANDSINK | PIPE | HEATING | REF 9
Port_2142663_0 | SOURCEANDSINK | PIPE | HEATING | REF 9
InPort_2107456_1 | SINK | PIPE | HEATING | REF 9
OutPort_2107458_0 | SOURCE | PIPE | HEATING | REF 9
InPort_2107458_1 | SINK | PIPE | HEATING | REF 9
OutPort_2109362_1 | SOURCE | PIPE | HEATING | REF 9
InPort_2107497_1 | SINK | PIPE | HEATING | REF 9
OutPort_2107499_0 | SOURCE | PIPE | HEATING | REF 9
InPort_2107499_1 | SINK | PIPE | HEATING | REF 9
OutPort_2109400_1 | SOURCE | PIPE | HEATING | REF 9
InPort_2109081_1 | SINK | PIPE | HEATING | REF 2
OutPort_2107554_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2107554_1 | SINK | PIPE | HEATING | REF 2
OutPort_2128865_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2129190_2 | SINK | PIPE | HEATING | REF 2
OutPort_2107595_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2107595_1 | SINK | PIPE | HEATING | REF 2
OutPort_2129051_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2107904_1 | SINK | PIPE | HEATING | REF 2
OutPort_2108023_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2107906_1 | SINK | PIPE | HEATING | REF 2
OutPort_2108015_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2108015_0 | SINK | PIPE | HEATING | REF 2
OutPort_2108053_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2108022_1 | SINK | PIPE | HEATING | REF 2
OutPort_2108054_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2108023_1 | SINK | PIPE | HEATING | REF 2
OutPort_2108022_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2108053_1 | SINK | PIPE | HEATING | REF 2
OutPort_2129372_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2108054_0 | SINK | PIPE | HEATING | REF 2
OutPort_2129371_2 | SOURCE | PIPE | HEATING | REF 2
Port_2108447_3 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_2108447_4 | SINK | PIPE | HEATING | REF 2
OutPort_2109081_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2109400_2 | SINK | PIPE | HEATING | REF 9
OutPort_2108447_5 | SOURCE | PIPE | HEATING | REF 9
Port_2108535_3 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_2108535_4 | SINK | PIPE | HEATING | REF 2
OutPort_2129190_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2109362_2 | SINK | PIPE | HEATING | REF 9
OutPort_2108535_5 | SOURCE | PIPE | HEATING | REF 9
InPort_2110236_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2120980_0 | SOURCE | PIPE | HEATING | RIS 10
InPort_2110237_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2110236_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2110279_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2110236_3 | SOURCE | PIPE | HEATING | RIS 10
InPort_2110277_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2110279_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2110622_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2110709_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2111475_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2119289_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2111475_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2112540_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_2112447_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2112339_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2112448_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2112379_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2112510_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2119290_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_2112511_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2112510_2 | SOURCE | PIPE | HEATING | RIS 10
Port_2113377_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2113395_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2113387_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2113395_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2113387_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2113404_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2113398_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2113404_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2113398_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2156939_1 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2113441_2 | SINK | PIPE | HEATING | REF 2
OutPort_2113423_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2113433_0 | SINK | PIPE | HEATING | REF 2
OutPort_2113441_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2113450_1 | SINK | PIPE | HEATING | REF 2
OutPort_2113433_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2113444_0 | SINK | PIPE | HEATING | REF 2
OutPort_2113450_2 | SOURCE | PIPE | HEATING | REF 2
InPort_2144336_1 | SINK | PIPE | HEATING | REF 2
OutPort_2113444_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2113493_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2113469_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2113485_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2113493_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2113504_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2113485_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2113496_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2113504_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2156995_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2113496_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2113525_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2113543_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2113535_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2113543_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2113535_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2157039_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2113546_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2157039_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2113546_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2157042_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_2113625_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2113605_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2113617_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2113625_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2158594_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2113617_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2113628_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2158594_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2158597_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2113628_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_2113657_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2113673_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2113665_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2113673_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2113665_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2158562_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2113676_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2158562_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2113676_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2158565_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2119099_1 | SINK | PIPE | HEATING | REF 13
OutPort_2140767_1 | SOURCE | PIPE | HEATING | REF 13
InPort_2141361_1 | SINK | PIPE | HEATING | REF 8
OutPort_2119099_2 | SOURCE | PIPE | HEATING | REF 8
InPort_2142613_1 | SINK | PIPE | HEATING | REF 9
OutPort_2119099_3 | SOURCE | PIPE | HEATING | REF 9
InPort_2119099_4 | SINK | PIPE | HEATING | REF 14
OutPort_2140910_1 | SOURCE | PIPE | HEATING | REF 14
OutPort_2119099_5 | SOURCE | PIPE | VENT
OutPort_2119099_6 | SOURCE | PIPE | SEWAGE
InPort_2119235_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2119280_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2119280_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2119295_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2119289_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2119290_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2119295_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2121177_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_2121911_0 | SINK | PIPE | HEATING | RIS 7
OutPort_2119433_1 | SOURCE | PIPE | HEATING | RIS 7
Port_2119618_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2119628_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2119618_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121084_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2119631_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121084_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2119631_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121086_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_2119681_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2119665_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2119673_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2119681_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2122387_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2119673_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2119684_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2122387_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2122389_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2119684_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2119722_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2119730_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2120997_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2119722_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2119733_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2120997_1 | SOURCE | PIPE | HEATING | RIS 10
InPort_2120999_2 | SINK | PIPE | HEATING | RIS 10
OutPort_2119733_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2119791_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2119841_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2119833_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2119841_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2119833_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121922_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2119844_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121922_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2119844_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121924_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_2120469_0 | SINK | PIPE | HEATING | RIS 10
OutPort_2121608_2 | SOURCE | PIPE | HEATING | RIS 10
InPort_2121248_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2120469_1 | SOURCE | PIPE | HEATING | RIS 10
Port_2120575_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2127900_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2120575_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2121608_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2120729_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122970_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2120729_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121861_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2120749_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122970_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2120749_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122972_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_2120980_1 | SINK | PIPE | HEATING | RIS 10
OutPort_2120979_2 | SOURCE | PIPE | HEATING | RIS 10
Port_2121137_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121170_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121170_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121171_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_2121176_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2121609_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2121176_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2121177_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2121608_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2121609_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
InPort_2354312_2 | SINK | PIPE | HEATING | RIS 7
OutPort_2121852_0 | SOURCE | PIPE | HEATING | RIS 7
InPort_2121852_1 | SINK | PIPE | HEATING | RIS 7
OutPort_2121880_1 | SOURCE | PIPE | HEATING | RIS 7
Port_2121861_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122376_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121861_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121862_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121862_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121910_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121908_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121910_3 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121908_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2121924_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_2121910_2 | SINK | PIPE | HEATING | RIS 7
OutPort_2121911_1 | SOURCE | PIPE | HEATING | RIS 7
OutPort_2122373_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_2122373_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_2122389_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_2122375_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122376_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122375_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354313_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_2161198_0 | SINK | PIPE | HEATING | POST 1
OutPort_2122375_3 | SOURCE | PIPE | HEATING | POST 1
Port_2122409_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143532_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2122535_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143556_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2122566_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2158179_3 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2122960_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122962_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122960_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122972_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2122962_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354080_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2127900_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2158180_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2127918_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2127927_0 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2127918_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2158255_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2127918_3 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2127931_0 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2127918_4 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2127933_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2127927_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2143762_1 | SOURCEANDSINK | PIPE | HEATING | RIS 6
Port_2127931_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2143787_1 | SOURCEANDSINK | PIPE | HEATING | RIS 8
Port_2127933_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2158197_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2128196_0 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2158179_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2128196_1 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2158197_2 | SOURCEANDSINK | PIPE | HEATING | RIS 10
Port_2128329_0 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354079_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2128329_1 | SOURCEANDSINK | PIPE | HEATING | RIS 7
Port_2354107_2 | SOURCEANDSINK | PIPE | HEATING | RIS 7
InPort_2129371_3 | SINK | PIPE | HEATING | REF 2
OutPort_2129369_0 | SOURCE | PIPE | HEATING | REF 2
InPort_2129369_1 | SINK | PIPE | HEATING | REF 2
OutPort_2129537_1 | SOURCE | PIPE | HEATING | REF 2
InPort_2129372_1 | SINK | PIPE | HEATING | REF 2
OutPort_2129371_1 | SOURCE | PIPE | HEATING | REF 2
Port_2129585_2 | SOURCEANDSINK | PIPE | HEATING | REF 13
Port_2159311_0 | SOURCEANDSINK | PIPE | HEATING | REF 13
InPort_2135350_0 | SINK | PIPE | HEATING | REF 13
OutPort_2140780_2 | SOURCE | PIPE | HEATING | REF 13
InPort_2140782_2 | SINK | PIPE | HEATING | REF 13
OutPort_2135350_1 | SOURCE | PIPE | HEATING | REF 13
InPort_2140767_2 | SINK | PIPE | HEATING | REF 13
OutPort_2140708_0 | SOURCE | PIPE | HEATING | REF 13
InPort_2140708_1 | SINK | PIPE | HEATING | REF 13
OutPort_2140782_1 | SOURCE | PIPE | HEATING | REF 13
InPort_2140780_1 | SINK | PIPE | HEATING | REF 13
OutPort_2159301_1 | SOURCE | PIPE | HEATING | REF 13
InPort_2140910_2 | SINK | PIPE | HEATING | REF 14
OutPort_2144395_0 | SOURCE | PIPE | HEATING | REF 14
InPort_2141334_0 | SINK | PIPE | HEATING | REF 8
OutPort_2141361_2 | SOURCE | PIPE | HEATING | REF 8
InPort_2144050_1 | SINK | PIPE | HEATING | REF 8
OutPort_2141334_1 | SOURCE | PIPE | HEATING | REF 8
Port_2141762_0 | SOURCEANDSINK | PIPE | HEATING | REF 9
Port_2142662_1 | SOURCEANDSINK | PIPE | HEATING | REF 9
InPort_2142119_0 | SINK | PIPE | HEATING | REF 9
OutPort_2142613_2 | SOURCE | PIPE | HEATING | REF 9
InPort_2142630_1 | SINK | PIPE | HEATING | REF 9
OutPort_2142119_1 | SOURCE | PIPE | HEATING | REF 9
InPort_2142622_0 | SINK | PIPE | HEATING | REF 9
OutPort_2142630_2 | SOURCE | PIPE | HEATING | REF 9
InPort_2142666_1 | SINK | PIPE | HEATING | REF 9
