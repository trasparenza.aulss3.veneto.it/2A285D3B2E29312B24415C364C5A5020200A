Properties of the parts of a building model (IFC4), part 6 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1325590_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1818266_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325591_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325595_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1809285_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325591_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325592_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1809258_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325595_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325602_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325596_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325597_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325597_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325610_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325610_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325599_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325599_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325611_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325601_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325600_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325611_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325601_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325602_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1881183_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325687_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1814045_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1814042_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325687_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1326044_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1881182_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1881183_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1326044_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1326959_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1809885_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1327133_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1328510_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1327135_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1327133_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1810130_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1327135_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1327953_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1327958_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1328076_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1327953_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1327958_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1819533_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1328067_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1818328_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1815144_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1328067_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1818328_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1328076_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1332801_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1328372_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1328372_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1815144_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1328510_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1819676_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1331006_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1812863_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1331803_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1331006_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1331152_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1812207_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1837201_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1331803_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1812866_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332117_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1332117_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1333420_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1812210_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332187_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1332187_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332390_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1332390_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332754_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1332754_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332899_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1332899_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332801_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1814176_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332801_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1333420_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1332801_11 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1334096_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334094_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1334235_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334094_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1916191_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334096_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1910023_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334235_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1334291_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1910054_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1334592_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334542_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1334542_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334638_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1334542_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1920962_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1920964_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1334542_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1334638_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334923_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1334921_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1336729_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1334923_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334921_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1335006_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1335011_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1335959_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1335006_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1335547_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1335006_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1335011_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1783551_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1335241_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1335250_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1335304_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1335241_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1335266_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1335304_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850464_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1335266_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1335557_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1335547_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1336012_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1336007_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1336146_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1336007_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849268_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1336012_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1910364_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1336146_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1336729_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1910364_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1337472_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1338912_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1337491_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1338808_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1338517_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1337491_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1337591_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1337797_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1339303_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1337591_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1338471_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1339303_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1339315_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1338471_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1338510_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1338517_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1338534_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1338510_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1338808_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1338813_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1338886_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1338808_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1338813_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1907670_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1338912_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1338886_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1339311_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1339315_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1340365_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1339311_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1339340_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1555245_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1907640_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1339340_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1339340_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1555779_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1555835_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1339340_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1339554_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1340365_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1555245_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1339554_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1340126_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1907623_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1907672_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1340126_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1908168_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1340126_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1907670_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1340128_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1340128_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1907672_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1495978_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 5
OutPort_1346373_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 5
InPort_1496036_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 4
OutPort_1346373_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 4
Port_1361513_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500627_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1361513_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499746_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1361701_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500627_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1361701_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500653_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1362831_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646329_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1362831_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500008_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1362832_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500442_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1362832_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500008_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1362834_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500442_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1362834_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1500466_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1363174_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1646308_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1363174_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499276_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1363175_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499350_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1363175_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499276_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1363177_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499350_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1363177_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
Port_1499370_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 25
InPort_1431266_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1363383_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1363383_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1402651_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365556_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1363418_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1363418_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365559_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1363739_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365389_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1432463_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1363739_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1431148_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1363769_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1363769_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1398600_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1363807_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364452_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1398432_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1363807_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1364281_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364142_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1364142_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364222_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1364142_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364988_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1364142_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365082_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1364440_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364281_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1364452_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364440_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1364813_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364538_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1364714_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364650_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1364988_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364714_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365082_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1364813_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365300_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365297_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365297_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1430198_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365298_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365299_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1430226_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365298_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365298_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365308_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365298_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365309_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1430522_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365300_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1430198_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365302_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365302_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1430226_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365307_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365304_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365306_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365305_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365308_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365306_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365309_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365307_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365378_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1430520_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365389_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365378_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1402524_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365456_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365456_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365462_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365460_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365457_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365457_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365458_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365457_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365467_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365457_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365468_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365461_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365460_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365462_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365461_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365466_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365463_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365465_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365464_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365467_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365465_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365468_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365466_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1370568_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365469_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365469_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365475_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365473_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365470_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365470_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365471_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365470_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365480_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365470_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365481_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365474_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365473_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365475_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365474_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365479_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365476_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365478_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365477_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365480_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365478_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365481_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365479_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1428050_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1365556_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1365559_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1370570_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1509162_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 14
OutPort_1365961_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 14
InPort_1509205_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 13
OutPort_1365961_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 13
Port_1365989_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1490189_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365989_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1490192_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365990_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1490311_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365990_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1490192_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365992_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1490311_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365992_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1510007_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365995_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1646012_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365995_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1489972_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365996_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1490056_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365996_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1489972_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365998_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1490056_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1365998_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1509902_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1366007_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1482543_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1366007_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_2406515_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1366008_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1486810_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1366008_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1482543_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1366013_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1480987_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1366013_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1645992_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1366014_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1846693_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1366014_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1480987_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
InPort_1366024_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438585_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438587_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366024_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1370482_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366025_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366025_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1501907_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366026_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438467_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438469_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366026_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366028_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438505_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438507_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366028_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366029_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1438564_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438566_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366029_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1370501_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366030_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366030_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1501521_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366032_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366038_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1501521_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366032_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366036_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366033_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366033_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366034_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366033_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366043_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366033_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366044_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366037_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366036_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366038_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366037_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366042_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366039_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366041_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366040_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366043_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366041_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366044_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366042_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366049_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366046_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366046_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366047_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366046_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366056_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366046_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366057_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366050_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366049_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1402935_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366050_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366055_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366052_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366054_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366053_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366056_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366054_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366057_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366055_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438505_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366058_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366058_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1501772_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366060_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1501905_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1501907_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366060_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366063_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366061_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366061_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366062_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366061_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366070_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366061_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366071_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366064_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366063_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1501905_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366064_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366069_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366066_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366068_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366067_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366070_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366068_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366071_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366069_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1502050_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366072_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366072_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366077_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366075_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366073_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366073_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366074_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366073_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366082_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366073_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366083_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366076_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366075_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366077_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366076_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366081_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366078_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366080_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366079_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366082_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366080_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1366083_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1366081_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1370484_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1370482_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438585_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1370484_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1370503_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1370501_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1438564_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 14
OutPort_1370503_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 14
InPort_1370570_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 9
OutPort_1370568_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 9
InPort_1502482_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 18
OutPort_1370993_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 18
InPort_1502397_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 15
OutPort_1370993_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 15
Port_1371021_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503754_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371021_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503757_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371022_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371025_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371022_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503757_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371024_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371025_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371024_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503919_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371027_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645522_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371027_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502680_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371028_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502643_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371028_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502680_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371030_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502643_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371030_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502963_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371039_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503314_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371039_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503317_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371040_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503613_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371040_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503317_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371042_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503613_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371042_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503616_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371045_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1645623_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371045_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502785_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371046_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503106_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371046_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1502785_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371048_0 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503106_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1371048_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
Port_1503109_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 11
InPort_1439168_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371056_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371056_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371115_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1439388_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371058_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371058_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371113_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371113_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371059_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371059_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371126_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1439360_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371060_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371060_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371118_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1439142_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371061_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371061_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371063_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371122_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371062_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371062_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371296_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371063_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371123_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371296_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371064_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371064_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371070_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371068_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371065_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371065_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371066_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371065_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371075_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371065_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371076_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371069_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371068_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371070_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371069_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371074_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371071_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371073_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371072_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371075_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371073_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371076_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371074_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1403227_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371077_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371077_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1403187_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371080_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371078_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371078_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371079_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371078_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371086_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371078_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371087_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371081_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371080_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1403187_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371081_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371085_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371082_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371084_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371083_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371086_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371084_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371087_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371085_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371118_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371088_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371088_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1403186_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1372881_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371089_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371089_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371094_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371092_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371090_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371090_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371091_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371090_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371099_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371090_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371100_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371093_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371092_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371094_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371093_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371098_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371095_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371097_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371096_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371099_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371097_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371100_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371098_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371101_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371106_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1372210_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371101_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371104_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371102_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371102_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371103_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371102_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371111_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371102_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371112_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371105_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371104_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371106_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371105_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371110_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371107_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371109_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371108_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371111_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371109_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371112_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371110_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371115_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371121_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371120_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1372778_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371121_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371120_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371123_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371122_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371126_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1371811_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1371811_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1372210_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1372778_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 15
OutPort_1372881_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 15
InPort_1379480_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1373057_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1379456_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
OutPort_1373057_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 32 (1)
InPort_1379521_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1373092_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1379501_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 34
OutPort_1373092_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 34
InPort_1373641_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1373553_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1373678_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1373553_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374113_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1373641_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374025_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1373678_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1373845_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_2435170_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1851061_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1373845_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374041_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1373953_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374353_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1373953_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1373953_3 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374025_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374127_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374059_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374483_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374059_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374059_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374113_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_2435172_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374217_8 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374217_9 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1375412_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374217_10 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1375570_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1375412_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374295_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374295_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374498_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374445_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374329_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374329_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374353_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1375570_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374345_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374345_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374462_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374438_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374445_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374462_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
OutPort_1374438_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
InPort_1374474_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 19 (1)
