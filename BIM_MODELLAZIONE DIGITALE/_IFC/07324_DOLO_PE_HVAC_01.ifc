Properties of the parts of a building model (IFC4), part 13 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1810688_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1810690_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1811174_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1811413_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1817957_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1811759_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1812036_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1812038_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1812205_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1812210_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1812209_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1812205_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1812207_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1812209_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1812861_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1812866_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1812865_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1812861_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1812863_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1812865_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1813037_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1813413_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1813040_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1813175_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1813685_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1814380_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1813689_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1813685_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1813687_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1813689_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1813879_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1813877_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1814381_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1814176_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1815284_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1815144_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1818252_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1815284_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1818250_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1818252_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1818255_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1818250_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1818251_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1818255_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1818266_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1818251_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1823313_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1822316_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1823357_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1823313_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1823356_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1823313_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1823574_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1823580_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2436674_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1823574_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1823576_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2436674_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2436705_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1823576_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1824971_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1824918_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1824936_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1824971_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1824970_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1824936_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434095_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1824970_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1825044_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1886595_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1825428_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1825145_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1825395_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1825411_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1825411_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1825404_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1825404_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1825428_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1826407_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1826414_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1827179_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1874967_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1827531_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1827617_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1828016_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1827531_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1827531_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1828826_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1914836_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1827932_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1827959_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1914785_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1828197_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1828176_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1828828_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1828197_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1828206_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1828828_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1828826_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1828206_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1828874_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1828867_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829262_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829183_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829195_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829213_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829213_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829206_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829206_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829262_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829344_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829380_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2434799_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829344_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829867_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829769_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829867_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2434795_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829996_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2434491_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2353013_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829996_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1830488_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1830481_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1830481_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1830505_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1830494_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2353013_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1830505_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1830494_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435095_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833461_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435095_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833463_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2435029_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1833814_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1834096_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1834089_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1834089_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1834146_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1834146_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1834102_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1834102_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1834148_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
Port_1846681_1 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
Port_1846693_2 | SOURCEANDSINK | DUCT | VENTILATION | Meccanico Aria di mandata 8
InPort_1848680_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864111_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849915_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1848680_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1848690_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849915_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850096_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1848690_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1848970_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1848981_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849348_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849358_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849349_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849360_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849351_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849350_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849350_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849513_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849352_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849351_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849378_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849352_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849353_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849364_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849354_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849353_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849357_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849353_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849356_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849354_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849355_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849356_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849362_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849355_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849374_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849357_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849358_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849362_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849360_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849374_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849363_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849378_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849376_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849363_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849364_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1849376_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1849688_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864092_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850008_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849688_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849691_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849689_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1864088_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849690_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849690_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849691_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849691_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849735_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849691_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849758_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850098_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1849997_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1849997_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850008_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1910575_10 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850117_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850463_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2406098_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1972743_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853046_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853046_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853187_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853078_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972745_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853155_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853078_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853153_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853155_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853163_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853153_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853187_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853185_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853185_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853195_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853804_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853802_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853802_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853814_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1916551_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853804_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853805_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1916550_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1919275_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853805_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1853852_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853854_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853864_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853852_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853854_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1916585_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1916584_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853855_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853855_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1919277_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853962_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972677_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1854112_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1853962_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972672_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1853992_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1853992_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1854037_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1854037_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1854035_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1854035_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1854045_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1854110_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1854112_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1854120_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1854110_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1854268_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1922969_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1854307_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1854268_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1854305_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1854307_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1854315_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1854305_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1971402_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1854354_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1873455_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1854957_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1854957_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1936358_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1855009_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1872265_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872222_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1855009_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870176_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1856054_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1856054_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1860737_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1856940_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1856942_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1856952_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1856940_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1856942_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1856943_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1856943_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857039_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1856977_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1856975_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1856975_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1856987_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857010_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1856977_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857015_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857010_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857016_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857015_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857087_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857016_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857037_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1857039_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1857049_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1857037_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857039_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857040_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857040_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857122_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1857087_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857085_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857085_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857097_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857088_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857087_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857220_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857088_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857120_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1857122_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1857132_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1857120_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857122_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857123_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857123_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857258_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1857220_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857218_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857218_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857232_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937484_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857220_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857256_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1857258_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1857270_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1857256_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857258_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857259_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857259_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937518_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857462_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1887602_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1857462_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1887604_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1887569_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857494_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857494_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1887571_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937270_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1857704_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1857704_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937217_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1921271_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1859421_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1859421_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860296_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1859453_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1921273_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1859916_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1859453_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1859914_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1859916_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1859924_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1859914_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1860273_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860292_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1860296_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860273_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1860286_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860288_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1860292_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860286_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1860698_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860696_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1860696_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860780_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1860737_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1860735_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1860735_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1860747_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1860737_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1860738_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1860738_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1936028_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1860747_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1920865_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1860770_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860772_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1860784_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860770_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1860772_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1860939_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1860772_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1936030_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860773_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1860773_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1920882_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1860784_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1860939_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1870143_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1864092_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864086_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1864086_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864091_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1864091_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864088_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1864111_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864106_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1864106_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864110_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1864110_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1864108_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1923016_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1869619_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1869619_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1869660_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1869826_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1869838_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870186_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1869826_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1869841_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870186_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870190_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1869841_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870141_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1870143_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1870155_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1870141_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1870143_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1870144_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1870144_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1936332_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1870176_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870174_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870174_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870190_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870177_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870176_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936382_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870177_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870563_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1872222_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870587_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870563_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870579_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870587_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870629_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870579_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870592_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870629_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870631_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870592_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1870632_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870631_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936413_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1870632_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872265_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1872263_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872263_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1872275_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872265_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1872266_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872446_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1872438_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872438_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1872638_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872638_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1872449_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1872449_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1971404_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1873453_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1873455_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1873465_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1873453_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1873456_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1873455_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875180_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1873456_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1874907_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1874919_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1874927_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1874907_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1874922_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1874927_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1874937_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1874922_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1874930_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1874937_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1874967_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1874930_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1971650_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875135_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875135_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875259_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875196_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875206_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875257_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875196_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875211_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875257_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875259_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875211_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875644_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1875642_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1875642_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1876040_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1875645_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1875644_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1875676_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875678_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1876005_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875676_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1875679_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875678_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1919277_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1875679_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1877519_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1876005_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1876040_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1877485_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1876921_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1876930_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1876947_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1876921_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1877352_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1877336_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1877345_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1877352_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1877367_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1877345_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1877484_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1877482_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1877482_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1877494_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1877484_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1972640_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1877485_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1877484_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1877516_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1877518_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1877528_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1877516_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972617_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1877518_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1877518_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1877519_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1972329_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1877728_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1877728_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1877801_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1877801_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1877799_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1877799_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1877814_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1878094_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1878389_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1878391_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1878094_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1878683_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1878681_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1878681_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1973306_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1878684_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1878683_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1972653_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1878684_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1878720_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1878722_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1973332_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1878720_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1878722_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1878723_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1878723_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1972651_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880013_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880011_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880011_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880025_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880796_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880013_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880014_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880795_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1881332_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880014_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880108_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880113_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880113_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880165_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880165_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880120_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880120_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880169_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880153_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880155_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880169_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880153_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1880155_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1918069_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1880482_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1880722_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1880482_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1881275_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1918036_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880509_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880720_0 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880722_3 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880732_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880720_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1880722_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1918259_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880881_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880732_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880795_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880793_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880793_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880807_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880795_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1918025_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1918024_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880796_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880851_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880803_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880850_3 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880848_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880848_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880860_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880850_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1880851_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1880886_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880881_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1880887_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1880886_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1881273_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1881275_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1881273_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1881284_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1881330_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1881332_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1881340_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1881330_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1881481_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1887604_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1881481_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937442_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1887571_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1881537_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1881537_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937461_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
Port_1881824_0 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937235_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1881824_1 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
Port_1937194_2 | SOURCEANDSINK | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937366_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1887140_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1887140_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937528_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937491_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1887173_0 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1887173_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1889157_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937323_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1887239_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1887239_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1887479_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1887281_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937325_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1887360_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1887281_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1887358_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1887360_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1887368_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1887358_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1887479_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1887467_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1887467_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1887483_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1937528_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1887660_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1887660_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1937530_2 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1887699_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937491_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937493_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1887699_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1887713_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937483_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1937461_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1887713_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1888135_2 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1888133_0 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1888133_1 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1888143_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1888172_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1888174_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1888182_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1888172_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1888456_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1888473_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1936694_2 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1888456_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1888467_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1888469_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1888473_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1888467_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1889032_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1937362_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1889147_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1889032_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1889145_0 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1889147_2 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1889157_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1889145_1 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1890410_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1890130_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1892386_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1892393_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1892410_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1892386_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1896796_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1897723_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1896799_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1897726_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1897726_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1897296_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1900123_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1899817_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1899817_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900199_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900097_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900088_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900088_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900260_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900088_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900123_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900232_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900189_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900199_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900192_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900245_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900232_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900261_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900245_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900260_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900253_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900253_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900261_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900700_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1900685_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1900685_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1900687_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1900687_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1900688_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1900689_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1900687_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1902510_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1900689_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1900691_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1900700_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1901999_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1900691_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1900998_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1901722_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1903366_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1901791_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1901989_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1902510_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1901992_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1901999_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1903312_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1903366_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1903940_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1903802_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1905071_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1905078_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1916649_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1905071_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1905756_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1916666_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1906700_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1906707_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1906752_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1906700_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1906745_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1906752_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1906837_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1906853_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1906853_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1906846_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1906846_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1906868_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1907160_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1907134_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1907623_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1907640_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1908220_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1908168_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1908213_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1908220_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1908955_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1909019_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1909020_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1908955_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1909041_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1909027_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1909027_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1909070_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1909070_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1909061_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1910016_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1910023_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1910054_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1910016_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1910575_9 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1910690_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1910690_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1910701_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2352950_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1910802_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1910802_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2352951_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2352951_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1910811_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1910811_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1910828_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1910828_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1910819_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1910819_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1910904_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
