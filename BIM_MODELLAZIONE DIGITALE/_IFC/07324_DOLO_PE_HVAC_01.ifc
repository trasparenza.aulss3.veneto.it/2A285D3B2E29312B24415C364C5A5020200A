Properties of the parts of a building model (IFC4), part 5 of 17

# IfcDistributionPort (11772)
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1284592_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1377768_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284742_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284667_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284667_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1377792_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284824_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1901989_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1284836_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1901992_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1900192_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284855_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900189_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1284867_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1284978_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1901683_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1901722_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1284978_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1901791_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1284978_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1284980_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1379215_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1287355_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1284980_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1285095_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1286234_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1286065_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1285095_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1377884_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1285228_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1285228_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1377887_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1286058_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1286065_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1286078_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1286058_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1287824_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1286069_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1286069_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1286078_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1286234_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1286236_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1286236_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1287448_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1287448_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1287691_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1287691_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1900097_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1291159_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1287824_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1900688_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1289570_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1289570_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1903312_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1903802_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1289885_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1289905_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1302947_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1904325_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1289937_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1289938_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301369_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1904684_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1289956_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1289957_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1905756_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1289976_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1291825_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1905903_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1289994_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1290423_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300944_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1904941_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1290424_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1906063_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1290482_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1290482_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1295173_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1290482_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1295217_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1295173_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1290646_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1290646_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1294997_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1290646_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1295136_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1290701_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1323744_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1294997_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1290701_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1290701_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1294839_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1291087_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1323742_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1323744_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1291087_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1291087_4 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1291357_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1291159_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1377884_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1323742_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1291159_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1291357_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1291335_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1291335_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1298099_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1292146_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1291408_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1291408_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1903940_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1291825_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1304224_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1292122_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1292146_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1298059_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1292122_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1292124_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1298059_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1298094_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1292124_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1901683_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1292283_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1304981_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1292283_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1294839_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293138_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293138_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297846_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293144_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293140_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293140_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293557_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293142_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293144_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297851_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293142_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293143_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297851_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297852_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293143_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293165_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297143_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1295136_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293165_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293170_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293166_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293166_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1294027_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293168_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293170_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297148_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293168_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293169_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297148_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297149_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293169_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1295217_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293204_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293204_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296945_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293209_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293205_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293205_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1294507_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293207_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293209_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296950_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293207_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293208_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296950_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296951_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293208_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293228_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1905961_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1905958_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293228_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293233_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293229_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293229_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1294495_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293231_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293233_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297490_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293231_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293232_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297490_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297491_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1293232_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1293557_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1904325_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1294027_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1904684_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1294495_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1905903_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1294507_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1904941_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1295480_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1295795_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1467264_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1295480_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1295713_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1467264_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2470238_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1295713_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1295795_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1299457_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296475_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1295797_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1295797_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1412926_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1295797_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1299496_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296158_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1295843_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1295843_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1466309_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1466309_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1295881_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1295881_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1628599_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296064_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1412924_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1412926_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296064_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296160_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296158_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296295_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296160_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296242_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296236_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296236_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296238_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296238_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296237_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296237_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1628525_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1299836_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296242_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296458_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296295_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1299987_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296456_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296456_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296458_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296477_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296475_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1911708_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296477_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296490_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1299692_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1337797_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296490_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296492_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1337591_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1314853_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1296492_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1296620_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296624_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1835446_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296620_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296621_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1835446_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850533_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296621_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296624_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296629_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296629_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850641_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296945_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296944_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1296944_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1296951_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297143_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297142_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297142_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297149_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1905961_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297484_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297484_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297491_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297846_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297845_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1297845_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1297852_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1298093_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1298094_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1298099_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1298093_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1298267_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1298299_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850641_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1298267_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1298299_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1307404_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1299446_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1911708_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1299468_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1299446_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1299457_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1299468_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1299692_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1299833_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1299833_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1299824_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1299824_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1299925_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1299925_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1299836_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1507659_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1299987_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1507700_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300128_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300128_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1507659_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300128_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974533_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974535_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1300128_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1300353_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300263_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300263_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1507700_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300698_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300353_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1306545_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300353_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300467_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1306548_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1905078_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300467_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300820_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300698_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301078_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300820_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300906_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300820_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300899_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1306313_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300951_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300899_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1306310_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300906_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1300944_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1300951_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301025_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301079_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301268_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301025_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301079_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301078_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301864_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301268_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301386_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301268_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301369_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301653_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301377_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305897_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301653_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301377_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305925_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301386_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301859_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301864_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1323521_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301859_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1302004_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301859_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1301995_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305593_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1302956_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1301995_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305634_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1302004_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1302947_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1302956_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1323526_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1303613_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1303613_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1323528_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1303622_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1323526_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1303656_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1303622_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1303973_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305056_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1304224_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1303973_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305056_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1304979_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1304979_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305342_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305342_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1304981_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305593_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305588_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305588_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305631_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305590_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305634_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305631_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305590_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305897_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305892_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305892_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305922_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305894_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305925_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1305922_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1305894_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1306313_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1306308_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1306308_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1306312_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1306312_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1306310_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1306548_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1306543_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1306543_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1306601_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1306601_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1306545_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1314826_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1307213_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1907134_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1307226_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307246_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1906745_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1307255_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1337472_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1908820_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1307284_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307307_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1908213_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1910897_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1307332_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1310790_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1307341_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1311290_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1307350_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307369_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334291_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1307378_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1916131_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1307404_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850458_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307404_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850460_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307404_5 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1909020_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850458_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1307435_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307435_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850461_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307435_4 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850463_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307435_5 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850464_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850461_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1307654_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307654_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850236_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1307654_5 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850238_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1309662_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_2352950_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1309666_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1309662_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1910701_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1309664_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1309664_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1309666_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850117_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1309876_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1309876_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850096_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1309876_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1850098_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1310295_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1910575_8 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850236_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1310295_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850238_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1310404_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1310404_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1310814_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1310814_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1310790_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_2406094_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1311077_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1311077_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1311307_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1311338_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1311290_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1311307_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1311300_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1311300_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1311338_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1311494_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1316278_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1850460_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1311494_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1906707_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1312474_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1312474_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1554461_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1312553_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1312518_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1312518_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313273_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1312555_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1312553_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313166_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1312555_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1312786_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313166_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1312876_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1312786_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1312843_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1312876_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313273_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313237_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313237_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313659_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313237_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1974794_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1974796_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1313237_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1313659_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313648_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313648_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313689_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313689_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313687_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313687_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1412349_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1412349_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313727_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313727_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1414522_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313757_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1414898_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1313853_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313757_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1914469_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313853_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1414904_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1313853_3 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1906868_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1314826_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1314972_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1314853_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1783873_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1314853_10 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1414898_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1314957_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1314957_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1413241_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1413241_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1314972_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2434795_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1315423_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1315423_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1830488_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1317046_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1315447_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1315447_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1907160_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1316311_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1315859_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1315859_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1317043_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1316278_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1316250_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1316250_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1316280_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1316252_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1317447_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1316280_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1316252_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1316309_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1316314_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829776_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1316309_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1316311_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1829776_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1829769_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1316311_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1316314_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1906837_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1316471_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1316466_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1316466_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1316470_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1316468_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1414904_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1316470_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1316468_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1316695_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1316471_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1554461_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1316504_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1316504_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1554470_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1316504_3 | SINK | PIPE | HEATING | Mandata Post 2 (1) (1)
OutPort_1554961_1 | SOURCE | PIPE | HEATING | Mandata Post 2 (1) (1)
InPort_1554842_1 | SINK | PIPE | HEATING | Ritorno Post 1 (1) (1)
OutPort_1316504_4 | SOURCE | PIPE | HEATING | Ritorno Post 1 (1) (1)
InPort_1554470_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1316695_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1317041_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1317046_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1317045_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1317041_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1317043_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1317045_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1317399_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1909041_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1909019_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1317399_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1317447_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1908820_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1317685_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1318351_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1909061_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1317685_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1318440_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1318038_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1318038_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1318441_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1318351_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1318440_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1318441_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 1
OutPort_1318391_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 1
InPort_1334094_8 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1318578_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1318578_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1334592_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_2406632_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1319319_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1319319_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322650_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1319319_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1330225_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1319617_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1327953_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1819676_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1319617_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1320050_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1320049_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1320049_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1320059_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1320146_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1320128_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1320138_0 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1320146_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1320162_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1320138_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1320151_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1320162_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1321271_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1320677_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1320677_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321051_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1320677_5 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321053_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1320859_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1813879_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1810340_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1320904_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1320950_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1320958_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1320970_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1320950_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1810310_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1320960_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1320960_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1320970_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1814638_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321026_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321026_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321271_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321026_3 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321273_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321051_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1810312_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321449_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1814640_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322650_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321449_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1808975_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321660_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1809080_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321788_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321788_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321800_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_2464745_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1321829_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321829_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1415301_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1321829_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322073_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1810690_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322075_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322144_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1810711_8 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1415301_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322144_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322144_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1814042_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1812038_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322338_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_2464743_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322410_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322410_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_2464745_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1323362_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322433_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322578_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1330429_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322598_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322578_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322593_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322598_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322919_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322593_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1322829_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322919_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1330225_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1322829_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1330429_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1323277_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1323277_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1809058_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1323362_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_2464743_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1809058_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1323362_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1323528_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 2
OutPort_1323521_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 2
InPort_1912183_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325530_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325535_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325531_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325532_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1912190_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325551_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325532_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325546_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325535_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325537_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325546_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325547_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325537_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325538_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1509074_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325557_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325538_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1509024_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325539_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325539_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325541_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1509074_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325540_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325540_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1509075_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325541_1 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325547_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1509024_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325551_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325558_0 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325557_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1814045_2 | SINK | DUCT | VENTILATION | Meccanico Aria di ritorno 6
OutPort_1325558_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di ritorno 6
InPort_1325600_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325588_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325588_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325595_9 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1325589_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1818265_1 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1881182_1 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325589_2 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
InPort_1818265_2 | SINK | DUCT | VENTILATION | Meccanico Aria di mandata 7
OutPort_1325590_0 | SOURCE | DUCT | VENTILATION | Meccanico Aria di mandata 7
