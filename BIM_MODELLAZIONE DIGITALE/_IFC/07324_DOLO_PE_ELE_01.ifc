Properties of the parts of a building model (IFC4), part 2 of 4

# IfcDistributionPort (2189)
Name | FlowDirection | PredefinedType | SystemType
Port_3951702_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3955283_1 | SOURCEANDSINK | CABLE | DATA
Port_3955670_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3955671_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3956102_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3956103_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3956400_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3957878_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3957879_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3958847_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3958863_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3963700_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3963700_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3963723_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3963723_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3963733_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3963733_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3963789_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3963789_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3963859_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3963859_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3963970_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3963970_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3964015_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3964015_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3964082_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3964082_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3964219_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3964219_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3970312_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3970486_1 | SOURCEANDSINK | CABLE | DATA
Port_3970585_1 | SOURCEANDSINK | CABLE | DATA
Port_3970863_1 | SOURCEANDSINK | CABLE | DATA
Port_3971050_1 | SOURCEANDSINK | CABLE | DATA
Port_3971210_1 | SOURCEANDSINK | CABLE | DATA
Port_3971219_1 | SOURCEANDSINK | CABLE | DATA
Port_3971693_1 | SOURCEANDSINK | CABLE | DATA
Port_3971909_1 | SOURCEANDSINK | CABLE | DATA
Port_3972416_1 | SOURCEANDSINK | CABLE | DATA
Port_3972597_1 | SOURCEANDSINK | CABLE | DATA
Port_3972896_1 | SOURCEANDSINK | CABLE | DATA
Port_3972932_1 | SOURCEANDSINK | CABLE | DATA
Port_3973632_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3975210_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4399719_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3976415_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4075582_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3976415_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101591_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3976445_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4569063_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3976445_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095012_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3976445_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391561_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3978707_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074375_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3978707_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074723_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3978811_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4075980_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3978811_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4075469_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979021_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979068_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979021_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101183_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979048_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084704_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979048_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979068_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4075220_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979068_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979372_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979138_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101173_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979138_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4100877_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979138_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4100764_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979372_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979449_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979384_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3996697_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979384_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979449_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979390_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3996697_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979390_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3979449_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4422497_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3982668_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097020_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3982668_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4063993_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3984707_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099380_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3984707_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4098771_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3984707_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104898_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3986736_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099046_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3986736_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3988178_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097047_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3988178_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4062358_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3992187_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113623_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3992187_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113624_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3994650_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4072959_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3994650_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113624_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3996003_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4072959_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3996003_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091775_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3998552_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391697_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_3998552_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4001658_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4008019_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4012553_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095030_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4012553_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4063993_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4013902_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4041738_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4047873_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4047874_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4048065_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4048714_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4049877_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4049974_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4050019_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4050785_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4050786_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4051181_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4051468_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4051882_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4051942_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4062358_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102445_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4062358_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4075220_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4063317_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4063993_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4063317_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4065255_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4065255_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102464_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4072050_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4390255_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4072341_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091558_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4072341_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113623_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4072352_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091558_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4072352_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4390255_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4073079_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391320_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4073079_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4399719_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4073206_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4073206_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4390752_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074375_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092784_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074375_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090628_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074376_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090624_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074376_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391757_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074515_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391697_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074515_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391757_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074594_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074594_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074707_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074679_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074707_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074679_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4074723_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4075469_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4096862_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4075582_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092248_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4075980_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090760_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4077603_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4077981_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078054_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078205_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078367_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078367_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101592_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078527_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103186_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078527_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104988_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078527_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103852_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078560_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4107988_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078560_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103956_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078566_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4107988_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078566_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078589_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084732_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078589_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084734_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078596_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084732_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078596_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078615_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078608_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078615_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078608_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078622_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078617_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078622_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078617_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084744_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078624_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084744_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078624_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084746_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078727_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103514_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078727_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103516_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078729_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103514_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078729_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078739_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078731_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078739_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078731_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078741_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078733_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078741_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078733_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103276_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078735_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095916_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078735_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103466_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078829_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103466_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078829_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103468_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078904_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103537_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078904_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103539_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078906_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103537_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078906_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078918_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078908_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078918_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078908_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078920_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078910_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078920_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078910_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103254_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078912_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095932_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078912_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103487_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078914_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103487_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4078914_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103489_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4080710_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4565505_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4080710_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4565507_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4081260_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 23
Port_4081262_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 23
Port_4081260_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 23
Port_4081262_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 23
Port_4081384_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132851_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4081384_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132845_3 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4081411_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082452_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4081411_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132851_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4081478_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4081478_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4081480_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4081480_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082500_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4081539_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 24
Port_4081541_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 24
Port_4081539_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 24
Port_4081541_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 24
Port_4081749_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082534_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4081749_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4081751_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4081751_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132998_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082442_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082452_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082442_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082474_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082472_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082516_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082472_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082474_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082500_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082516_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4082524_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082534_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082524_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082556_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082554_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4135171_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082554_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082556_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082583_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4135171_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4082583_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4135173_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4084686_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103468_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084686_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084692_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103489_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084692_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084701_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4100364_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084701_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084704_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084708_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103539_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084708_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084716_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103516_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084716_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084720_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084734_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084720_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084740_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084746_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4084740_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
InPort_4085681_2 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 1
OutPort_4085685_0 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 1
InPort_4085685_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4090176_2 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
InPort_4090180_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4085687_0 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
InPort_4085687_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4332554_1 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
Port_4088366_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4088489_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4088547_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4088635_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092411_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4088774_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092393_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4088790_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092307_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4089042_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4089580_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
InPort_4090167_2 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 12
OutPort_4332574_0 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 12
InPort_4090176_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4090174_0 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
InPort_4090174_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4090182_1 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
InPort_4090178_0 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4090180_2 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
InPort_4090182_2 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4090178_1 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
Port_4090624_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090625_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090624_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092983_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090625_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090627_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090627_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090628_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090627_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092973_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4090760_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091990_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091775_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391310_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091989_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091990_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091989_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091993_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091990_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091994_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091992_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091993_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091992_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4091994_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092199_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092023_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092199_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092023_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092241_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092332_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092241_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092311_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092247_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4096795_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092247_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092248_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092247_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092355_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092298_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092308_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092298_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092311_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092307_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092308_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092332_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092333_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092332_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092386_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092333_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092354_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092354_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092355_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092354_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092404_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092386_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092394_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092393_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092394_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092404_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092412_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092411_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092412_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092779_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092783_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092779_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092849_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092783_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092784_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092783_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092879_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092816_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092816_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092849_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092862_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092881_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092862_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092878_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092863_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092863_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092881_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092878_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092879_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092878_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092913_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092896_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113616_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092896_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092912_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092897_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113616_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092897_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092912_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092913_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092912_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092946_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092931_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092948_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092931_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092945_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092932_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092932_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092948_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092945_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092946_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092945_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4422631_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092973_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113613_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092974_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113613_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092974_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092983_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113615_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092984_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4113615_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4092984_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4093413_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4093415_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4093848_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101591_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4093848_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101592_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4094588_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4095012_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095046_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095029_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095030_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095029_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095054_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095038_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095049_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095038_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095054_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095045_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095046_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095045_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095049_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095900_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095916_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095900_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103278_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095920_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095932_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4095920_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103256_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4096795_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4096994_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4096862_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097061_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4096993_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4096994_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4096993_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097028_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097012_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097023_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097012_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097028_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097019_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097020_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097019_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097023_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097046_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097047_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097046_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097067_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097053_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097064_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097053_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097067_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097060_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097061_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097060_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4097064_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4098771_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099080_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4098894_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099090_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4098894_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099092_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099045_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099046_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099045_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099090_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099079_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099080_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099079_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099092_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099380_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099393_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099389_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099652_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099389_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099393_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099638_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099649_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099638_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099652_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099645_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099646_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099645_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099649_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4099646_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4569063_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4100364_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4100877_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4100764_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101221_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101173_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101175_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101174_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101175_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101174_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101183_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101210_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4400653_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101210_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101211_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4400653_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101211_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4101221_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102445_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102465_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102452_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102464_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102452_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102465_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102894_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103186_4 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4102894_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103256_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103065_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103186_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103065_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103278_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103186_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103186_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103398_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103186_5 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103417_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103254_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103417_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103276_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103398_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103852_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103950_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103930_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103953_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103930_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103956_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103950_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4103953_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104898_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104994_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104988_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104997_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104993_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104994_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104993_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4104997_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4107459_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522047_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4107459_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4523271_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4107459_3 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109207_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4107460_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522277_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4107460_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108338_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110181_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108338_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108508_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398777_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108508_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108524_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108518_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108524_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108518_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108546_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108930_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109024_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4108930_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109683_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109024_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109207_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398253_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109218_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398245_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109218_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109561_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109717_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109561_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109662_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109717_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109662_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4109683_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110105_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110181_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110105_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110258_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110212_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110256_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110212_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110246_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110256_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110246_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110258_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4110486_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4110528_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4112057_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4112478_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4114018_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4118383_1 | SOURCEANDSINK | CABLE | DATA
Port_4118416_1 | SOURCEANDSINK | CABLE | DATA
Port_4119179_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4120818_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4120837_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4121026_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4121037_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4121081_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4121744_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4121754_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4122332_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4122688_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123462_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123495_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123536_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123567_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123614_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123631_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123642_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123664_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123683_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123749_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123771_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123858_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123872_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123889_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4123926_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4124554_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4124810_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4124819_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4125110_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4125401_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4565509_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4125401_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4565511_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4125620_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4565509_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4125620_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4135610_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126571_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4137521_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4126571_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4565511_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4126580_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4135640_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126580_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126721_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126617_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126909_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126617_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126721_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126810_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4127698_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126810_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126911_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126846_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342592_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126846_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126911_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126909_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342593_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4126989_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127211_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4126989_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4131979_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127197_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127211_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127197_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4131767_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127214_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4131765_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127214_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4131767_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127240_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4131765_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127240_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127373_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127289_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127373_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127289_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127375_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127342_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127375_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127342_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127406_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127396_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127406_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127396_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127428_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127426_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127524_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127426_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127428_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127447_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342723_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127447_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127526_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127479_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127526_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127479_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127549_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127524_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342724_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127539_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127549_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127539_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127558_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127552_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127558_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127552_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127591_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127589_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127589_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127591_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4127698_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4128713_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 19
Port_4128713_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4565513_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128742_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128762_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128742_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128804_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128760_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4565513_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128760_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128762_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128802_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129397_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128802_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128804_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128823_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129397_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128823_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129407_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128889_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129568_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128889_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129407_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128917_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129709_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4128917_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130057_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129558_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129568_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129558_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129600_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129598_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4565515_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129598_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129600_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129674_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4371945_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129674_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129709_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129808_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130057_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4129808_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130059_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130001_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130059_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130001_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133327_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130072_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133296_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130072_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133298_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130199_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130345_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130199_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130921_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130333_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130345_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130333_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130370_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130368_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130368_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130370_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130544_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130666_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130544_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130694_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130627_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133296_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130627_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130666_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130680_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130694_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130680_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130703_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130697_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130703_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130697_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130772_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130706_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130772_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130706_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130774_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130737_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130923_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130737_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130774_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130873_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130921_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130873_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130923_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4130976_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131587_3 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
