Properties of the parts of a building model (IFC4), part 1 of 4

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 78b0544f-7bb4-4857-be44-ceb2b5880869, NumberOfSaves: 111], CoordinateReference [CoordinateBase: Coordinate condivise, ProjectSite: Interno]
File name: 07324
Time: 2025-02-28T17:56:48+01:00
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.11.26 (ITA) - IFC 24.1.11.26

# IfcProject: Ospedale di Dolo (VE), 07324
Description: PROGETTAZIONE ESECUTIVA DI N° 6 SALE OPERATORIE AL 3° PIANO BLOCCO EST OD 03D OSPEDALE DI DOLO (VE) - MODELLO ELETTRICO; LongName: 07324_DOLO_PE_ELE_00; Phase: ESECUTIVO

# IfcSite: Ospedale di Dolo (VE)
Description: Via Louis Pasteur, 11, 30031 Dolo VE; LongName: Piano terzo pronto soccorso ospedale di Dolo; RefLatitude: 45, 25, 19, 889831; RefLongitude: 12, 4, 4, 325637; RefElevation: 0 m

# IfcBuildingStorey: Livello:Vano tecnico (2)
Name | LongName | Elevation (m)
3 - Piano Terzo | 3 - Piano Terzo | 11.91 | Description: SALE OPERATORIE
4 - Piano Copertura | 4 - Piano Copertura | 16.61

# IfcAlarm: Dispositivi allarme incendio : F_CENTRALE RIVELAZIONE FUMI AD ASPIRAZIONE : 1 CANALE (2)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Centrale di rilevazione fumi ad aspirazione
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.2
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 200 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.057
Pset Main Dimensions - Main Dimensions: 300x200x150mm
Abaco IFCGUID - Famiglia e tipo: F_CENTRALE RIVELAZIONE FUMI AD ASPIRAZIONE: 1 CANALE; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Dispositivi allarme incendio : F_CENTRALE RIVELAZIONE FUMI AD ASPIRAZIONE :...) | Group
 1 CANALE | Meccanico Aria di ritorno 19; Meccanico Aria di ritorno 17
 1 CANALE | Meccanico Aria di ritorno 20

# IfcAlarm: Dispositivi allarme incendio : F_CENTRALE RIVELAZIONE FUMI AD ASPIRAZIONE : 2 CANALI (8)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Centrale di rilevazione fumi ad aspirazione
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.2
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 300 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.058
Pset Main Dimensions - Main Dimensions: 300x200x150mm
Abaco IFCGUID - Famiglia e tipo: F_CENTRALE RIVELAZIONE FUMI AD ASPIRAZIONE: 2 CANALI; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Dispositivi allarme incendio : F_CENTRALE RIVELAZIONE FUMI AD ASPIRAZIONE :...) | Group
 2 CANALI | Meccanico Aria di mandata 1; Meccanico Aria di ritorno 1
 2 CANALI | Meccanico Aria di ritorno 2; Meccanico Aria di ritorno 3
 2 CANALI | Meccanico Aria di ritorno 4; Meccanico Aria di ritorno 5
 2 CANALI | Meccanico Aria di ritorno 6; Meccanico Aria di ritorno 7
 2 CANALI | Meccanico Aria di ritorno 8; Meccanico Aria di ritorno 9
 2 CANALI | Meccanico Aria di ritorno 11; Meccanico Aria di ritorno 10
 2 CANALI | Meccanico Aria di ritorno 14; Meccanico Aria di ritorno 13
 2 CANALI | Meccanico Aria di ritorno 15; Meccanico Aria di ritorno 16

# IfcAudioVisualAppliance: Apparecchi elettrici : F_POSTAZIONE PC : MONITOR (2)
In: 3 - Piano Terzo
Type - PredefinedType: PLAYER; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Postazione PC per impianto telesorveglianza TVCC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 700 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.054
Pset Main Dimensions - Main Dimensions: 450x300x50mm
Abaco IFCGUID - Famiglia e tipo: F_POSTAZIONE PC: MONITOR; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi allarme incendio : F_PANNELLO LCD RIPETIZIONE ALLERMI : F_PANNELLO LCD RIPETIZIONE ALLARMI
In: 3 - Piano Terzo
Type - PredefinedType: DISPLAY; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Pannello LCD di ripetizione allarmi in locale presidiato
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.4
Pset Electrical Properties - Nominal Power: 30 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.07.01
Pset Main Dimensions - Main Dimensions: 250x100x50mm
Abaco IFCGUID - Famiglia e tipo: F_PANNELLO LCD RIPETIZIONE ALLERMI: F_PANNELLO LCD RIPETIZIONE ALLARMI; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi chiamata infermiera : F_TERMINALE DI REPARTO-CAMERA : CENTRALE DI REPARTO DA TAVOLO
In: 3 - Piano Terzo
Type - PredefinedType: SPEAKER; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Terminale di reparto-camera impianto di chiamata infermieri
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 50 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.033
Abaco IFCGUID - Famiglia e tipo: F_TERMINALE DI REPARTO-CAMERA: CENTRALE DI REPARTO DA TAVOLO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi chiamata infermiera : F_TERMINALE DI REPARTO-CAMERA : DA CAMERA (3)
In: 3 - Piano Terzo
Type - PredefinedType: SPEAKER; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Terminale di reparto-camera impianto di chiamata infermieri
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Nominal Power: 50 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.023
Abaco IFCGUID - Famiglia e tipo: F_TERMINALE DI REPARTO-CAMERA: DA CAMERA; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi di comunicazione : F_INTERFONO : INTERFONO ASETTICO (12)
In: 3 - Piano Terzo
Type - PredefinedType: SPEAKER; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Interfono di chiamata
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 20 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.035
Abaco IFCGUID - Famiglia e tipo: F_INTERFONO: INTERFONO ASETTICO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi di comunicazione : F_VIDEOCITOFONO : VIDEOCITOFONO DA PARETE (4)
In: 3 - Piano Terzo
Type - PredefinedType: SPEAKER; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Videocitofono di chiamata
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Nominal Power: 50 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.038
Abaco IFCGUID - Famiglia e tipo: F_VIDEOCITOFONO: VIDEOCITOFONO DA PARETE; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi di comunicazione : F_VIDEOCITOFONO : VIDEOCITOFONO DA TAVOLO (2)
In: 3 - Piano Terzo
Type - PredefinedType: SPEAKER; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Videocitofono di chiamata
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Nominal Power: 50 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.038
Abaco IFCGUID - Famiglia e tipo: F_VIDEOCITOFONO: VIDEOCITOFONO DA TAVOLO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi di sicurezza : F_BASE MICROFONICA : BASE MICROFONICA DA TAVOLO
In: 3 - Piano Terzo
Type - PredefinedType: MICROPHONE; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Base microfonica per annunci per impianto EVAC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.4
Pset Electrical Properties - Nominal Power: 50 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.001
Pset Main Dimensions - Main Dimensions: 350x300x150mm
Abaco IFCGUID - Famiglia e tipo: F_BASE MICROFONICA: BASE MICROFONICA DA TAVOLO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi di sicurezza : F_BASE MICROFONICA : BASE MICROFONICA VVF
In: 3 - Piano Terzo
Type - PredefinedType: MICROPHONE; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Base microfonica per annunci per impianto EVAC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.4
Pset Electrical Properties - Nominal Power: 50 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.001
Pset Main Dimensions - Main Dimensions: 450x250x150mm
Abaco IFCGUID - Famiglia e tipo: F_BASE MICROFONICA: BASE MICROFONICA VVF; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi di sicurezza : F_DIFFUSORE_DA INCASSO : F_DIFFUSORE_DA INCASSO (30)
In: 3 - Piano Terzo
Type - PredefinedType: SPEAKER; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Diffusore da incasso per impianto EVAC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.4
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 30 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: 165038d
Pset Main Dimensions - Main Dimensions: Ø250mm h:150mm
Abaco IFCGUID - Famiglia e tipo: F_DIFFUSORE_DA INCASSO: F_DIFFUSORE_DA INCASSO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcAudioVisualAppliance: Dispositivi di sicurezza : F_TELECAMERA_DOME : DOME_DA INTERNO (6)
In: 3 - Piano Terzo
Type - PredefinedType: CAMERA; Material: <Unnamed>, Vetro
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Telecamera di tipo DOME
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 60 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.055/ELE.056
Pset Main Dimensions - Main Dimensions: Ø210mm h:320mm
Abaco IFCGUID - Famiglia e tipo: F_TELECAMERA_DOME: DOME_DA INTERNO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcCableCarrierFitting: Raccordi passerella : M_Curvatura esterna verticale canale : Standard (43)
Type - PredefinedType: BEND; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Curva
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.03.02/VEN24-10.01.03.06/VEN24-10.01.03.05/VEN24-10.01.03.04/VEN24-10.01.03.07/VEN24-10.01.03.06
Abaco IFCGUID - Famiglia e tipo: M_Curvatura esterna verticale canale: Standard; WBS_01: DBE; WBS_02: IES
Name (Raccordi passerella : M_Curvatura esterna verticale canale :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Main Dimensions
3 x  Standard | 3 - Piano Terzo | P03 | 400x75mm
21 x  Standard | 3 - Piano Terzo | P03 | 300x75mm
3 x  Standard | 3 - Piano Terzo | P03 | 100x75mm
10 x  Standard | 3 - Piano Terzo | P03 | 200x75mm
 Standard | 3 - Piano Terzo | PC | 400x75mm
 Standard | 4 - Piano Copertura | PC | 400x75mm
4 x  Standard | 4 - Piano Copertura | PC | 500x75mm

# IfcCableCarrierFitting: Raccordi passerella : M_Curvatura interna verticale canale : Standard (26)
Type - PredefinedType: BEND; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Curva
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.03.02/VEN24-10.01.03.06/VEN24-10.01.03.05/VEN24-10.01.03.04/VEN24-10.01.03.07/VEN24-10.01.03.06
Abaco IFCGUID - Famiglia e tipo: M_Curvatura interna verticale canale: Standard; WBS_01: DBE; WBS_02: IES
Name (Raccordi passerella : M_Curvatura interna verticale canale :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Main Dimensions
15 x  Standard | 3 - Piano Terzo | P03 | 300x75mm
 Standard | 3 - Piano Terzo | P03 | 400x75mm
 Standard | 3 - Piano Terzo | P03 | 100x75mm
4 x  Standard | 3 - Piano Terzo | P03 | 200x75mm
5 x  Standard | 4 - Piano Copertura | PC | 500x75mm

# IfcCableCarrierFitting: Raccordi passerella : M_Curvatura orizzontale canale : Standard (27)
Type - PredefinedType: BEND; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Curva
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.03.02/VEN24-10.01.03.06/VEN24-10.01.03.05/VEN24-10.01.03.04/VEN24-10.01.03.07/VEN24-10.01.03.06
Abaco IFCGUID - Famiglia e tipo: M_Curvatura orizzontale canale: Standard; WBS_01: DBE; WBS_02: IES
Name (Raccordi passerella : M_Curvatura orizzontale canale :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Main Dimensions
11 x  Standard | 3 - Piano Terzo | P03 | 300x75mm
4 x  Standard | 3 - Piano Terzo | P03 | 100x75mm
3 x  Standard | 3 - Piano Terzo | P03 | 400x75mm
3 x  Standard | 4 - Piano Copertura | PC | 500x75mm
 Standard | 4 - Piano Copertura | PC | 400x75mm
5 x  Standard | 3 - Piano Terzo | P03 | 200x75mm

# IfcCableCarrierFitting: Raccordi passerella : M_Raccordo a T orizzontale canale : Raggio 300 mm (20)
Type - PredefinedType: TEE; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Raccordo
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.03.02/VEN24-10.01.03.06/VEN24-10.01.03.05/VEN24-10.01.03.04/VEN24-10.01.03.07/VEN24-10.01.03.06
Abaco IFCGUID - Famiglia e tipo: M_Raccordo a T orizzontale canale: Raggio 300 mm; WBS_01: DBE; WBS_02: IES
Name (Raccordi passerella : M_Raccordo a T orizzontale canale :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Main Dimensions
8 x  Raggio 300 mm | 3 - Piano Terzo | P03 | 400x75mm
11 x  Raggio 300 mm | 3 - Piano Terzo | P03 | 300x75mm
 Raggio 300 mm | 4 - Piano Copertura | PC | 500x75mm

# IfcCableCarrierFitting: Raccordi passerella : M_Riduttore canale : Standard (4)
In: 3 - Piano Terzo
Type - PredefinedType: REDUCER; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: riduttore
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.03.02/VEN24-10.01.03.06/VEN24-10.01.03.05/VEN24-10.01.03.04/VEN24-10.01.03.07/VEN24-10.01.03.06
Abaco IFCGUID - Famiglia e tipo: M_Riduttore canale: Standard; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Raccordi passerella : M_Riduttore canale :...) | Main Dimensions
2 x  Standard | 100x75mm
 Standard | 300x75mm
 Standard | 400x75mm

# IfcCableCarrierSegment: Attrezzatura elettrica : F_SETTO_REI : F_SETTO_REI (24)
In: 3 - Piano Terzo
Type - PredefinedType: CONDUITSEGMENT; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Setto REI per attraversamento passerelle elettriche
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 3.1.1
Pset Electrical Properties - Voltage: 230V/400V
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.02.01
Pset Main Dimensions - Main Dimensions: 510x100mm
Abaco IFCGUID - Famiglia e tipo: F_SETTO_REI: F_SETTO_REI; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcCableCarrierSegment: Passerelle : Passerella con raccordi : Passerella canale (143)
Type - PredefinedType: CABLETRAYSEGMENT
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Passerella per distribuzione impianti elettrici
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.03.02/VEN24-10.01.03.06/VEN24-10.01.03.05/VEN24-10.01.03.04/VEN24-10.01.03.07/VEN24-10.01.03.06
Abaco IFCGUID - Famiglia e tipo: Passerella con raccordi: Passerella canale; WBS_01: DBE; WBS_02: IES
Name (Passerelle : Passerella con raccordi :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Main Dimensions
70 x  Passerella canale | 3 - Piano Terzo | P03 | 300x75mm
17 x  Passerella canale | 3 - Piano Terzo | P03 | 400x75mm
9 x  Passerella canale | 3 - Piano Terzo | P03 | 100x75mm
27 x  Passerella canale | 3 - Piano Terzo | P03 | 200x75mm
16 x  Passerella canale | 4 - Piano Copertura | PC | 500x75mm
2 x  Passerella canale | 3 - Piano Terzo | PC | 400x75mm
2 x  Passerella canale | 4 - Piano Copertura | PC | 400x75mm

# IfcCableCarrierSegment: Raccordi passerella : M_Curvatura esterna verticale canale : Standard
In: 4 - Piano Copertura
Type - PredefinedType: CABLETRAYSEGMENT; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: PC
Pset Descrizione_Entità - Descrizione: Curva
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.03.02/VEN24-10.01.03.06/VEN24-10.01.03.05/VEN24-10.01.03.04/VEN24-10.01.03.07/VEN24-10.01.03.06
Pset Main Dimensions - Main Dimensions: 500x75mm
Abaco IFCGUID - Famiglia e tipo: M_Curvatura esterna verticale canale: Standard; WBS_01: DBE; WBS_02: IES; WBS_03: PC

# IfcCommunicationsAppliance: Dispositivi dati : F_PRESA DATI_SU SCATOLA DA INCASSO : N.1 PRESA DATI SU SCATOLA 503 (5)
In: 3 - Piano Terzo
Type - PredefinedType: NETWORKAPPLIANCE; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Presa dati su scatola da incasso
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Nominal Power: 0 W
Pset RIF_Crono - RIF_Crono: M3_S6_G40
Pset RIF_EPU - RIF_EPU: VEN24-10.12.08.01
Pset Main Dimensions - Main Dimensions: 95x70x48mm
Abaco IFCGUID - Famiglia e tipo: F_PRESA DATI_SU SCATOLA DA INCASSO: N.1 PRESA DATI SU SCATOLA 503; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcCommunicationsAppliance: Dispositivi dati : F_PRESA DATI_SU SCATOLA DA INCASSO : N.2 PRESE DATI SU SCATOLA 503 (10)
In: 3 - Piano Terzo
Type - PredefinedType: NETWORKAPPLIANCE; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Presa dati su scatola da incasso
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Nominal Power: 0 W
Pset RIF_Crono - RIF_Crono: M3_S6_G40
Pset RIF_EPU - RIF_EPU: VEN24-10.12.08.02
Pset Main Dimensions - Main Dimensions: 95x70x48mm
Abaco IFCGUID - Famiglia e tipo: F_PRESA DATI_SU SCATOLA DA INCASSO: N.2 PRESE DATI SU SCATOLA 503; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcCommunicationsAppliance: Dispositivi dati : F_PRESA DATI_VOLANTE : N.1 PRESA DATI VOLANTE (24)
In: 3 - Piano Terzo
Type - PredefinedType: NETWORKAPPLIANCE; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Presa dati volante su controsoffitto
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Nominal Power: 0 W
Pset RIF_Crono - RIF_Crono: M3_S6_G40
Pset RIF_EPU - RIF_EPU: 095113/095164
Pset Main Dimensions - Main Dimensions: 22x35x50mm
Abaco IFCGUID - Famiglia e tipo: F_PRESA DATI_VOLANTE: N.1 PRESA DATI VOLANTE; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcCommunicationsAppliance: Dispositivi dati : F_PRESE DATI_SU SCATOLA DA ESTERNO_IP55 : N.1 PRESA DATI SU SCATOLA A 3 MODULI (26)
In: 3 - Piano Terzo
Type - PredefinedType: NETWORKAPPLIANCE; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Presa dati su scatola da esterno IP55
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Nominal Power: 0 W
Pset RIF_Crono - RIF_Crono: M3_S6_G40
Pset RIF_EPU - RIF_EPU: VEN24-10.12.08.01
Pset Main Dimensions - Main Dimensions: 95x70x48mm
Abaco IFCGUID - Famiglia e tipo: F_PRESE DATI_SU SCATOLA DA ESTERNO_IP55: N.1 PRESA DATI SU SCATOLA A 3 MODULI; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcCommunicationsAppliance: Dispositivi dati : F_RACK DATI TVCC : RACK 6U - 600x450
In: 3 - Piano Terzo
Type - PredefinedType: NETWORKHUB; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Rack dati per impianto telesorveglianza TVCC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.3
Pset Electrical Properties - Nominal Power: 600 W
Pset RIF_Crono - RIF_Crono: M3_S6_G40
Pset RIF_EPU - RIF_EPU: ELE.054
Pset Main Dimensions - Main Dimensions: 600x450cm
Abaco IFCGUID - Famiglia e tipo: F_RACK DATI TVCC: RACK 6U - 600x450; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcCommunicationsAppliance: Dispositivi di sicurezza : F_NVR : NVR
In: 3 - Piano Terzo
Type - PredefinedType: NETWORKHUB; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: NVR per impianto telesorveglianza TVCC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.3
Pset Electrical Properties - Nominal Power: 200 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.054
Pset Main Dimensions - Main Dimensions: 350x300x150mm
Abaco IFCGUID - Famiglia e tipo: F_NVR: NVR; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcDistributionPort (2189)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType
Port_3809845_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3810453_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3809845_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3811247_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3809968_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4565485_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
InPort_3809968_2 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 1
OutPort_4565487_1 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 1
Port_3810426_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3810449_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3810426_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3810453_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3810447_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4565485_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3810447_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3810449_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3810517_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3811247_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_3810517_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333005_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
InPort_4565487_2 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 1
OutPort_3810629_0 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 1
InPort_3810629_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 1
OutPort_4085681_1 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 1
InPort_4332638_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 12
OutPort_3810672_1 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 12
InPort_3810672_2 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 12
OutPort_4090167_1 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 12
Port_3810937_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4565489_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_3810937_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_4565491_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_3810959_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4565493_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3810959_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4565495_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3810975_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4565497_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3810975_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4565499_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3811411_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_3811421_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_3811411_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334321_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_3811419_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4565489_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_3811419_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_3811421_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_3811437_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_3811451_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_3811437_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_3811546_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_3811449_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_4565491_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_3811449_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_3811451_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_3811546_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 3
Port_3812027_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4565493_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812027_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812029_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812029_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812036_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812036_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812070_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812049_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812070_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812049_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812196_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812082_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812100_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812082_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812115_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812098_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4565495_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812098_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812100_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812107_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812115_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812107_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812237_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812136_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812237_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812136_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333287_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_3812164_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812196_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812164_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333317_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_3812337_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812355_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812337_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812373_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812353_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4565497_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812353_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812355_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812362_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812373_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812362_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812523_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812383_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812397_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812383_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812412_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812395_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4565499_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812395_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812397_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812404_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812412_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812404_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812501_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812499_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334811_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812499_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812501_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_3812521_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334872_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812521_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812523_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_3812638_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4565501_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3812638_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4565503_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3812654_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4008042_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3812654_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 10
Port_3813051_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813063_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813051_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813081_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813061_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4565501_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813061_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813063_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813070_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813081_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813070_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813219_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813093_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813107_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813093_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813122_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813105_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4565503_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813105_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813107_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813114_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813122_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813114_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813196_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813147_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813219_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813147_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4335977_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_3813163_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813196_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813163_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4335949_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_3813248_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813258_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813248_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813273_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813256_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4008019_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813256_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813258_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813265_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813273_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813265_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813389_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813283_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813303_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813283_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813318_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813301_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4008042_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813301_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813303_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813310_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813318_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813310_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813371_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813369_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335342_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813369_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813371_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_3813387_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335322_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813387_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3813389_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_3821976_1 | SOURCEANDSINK | CABLE | SECURITY
Port_3833878_1 | SOURCEANDSINK | CABLE | SECURITY
Port_3834317_1 | SOURCEANDSINK | CABLE | SECURITY
Port_3834420_1 | SOURCEANDSINK | CABLE | SECURITY
Port_3836965_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3837186_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3837314_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3837322_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3837550_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3837657_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3837991_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3838000_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3838008_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3838016_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3838088_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3838089_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3838090_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3839088_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3839097_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3839108_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3839802_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3839811_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3839819_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3839827_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3840876_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3840885_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3840899_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3840908_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3841201_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3841244_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3841419_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3841427_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3841435_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3841443_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3843014_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3843022_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3843030_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3843038_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3843052_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844385_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844522_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844627_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844641_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844766_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844781_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844862_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844874_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844886_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3844994_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3845009_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3845027_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3845042_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3845693_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3845702_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3845710_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3845724_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846717_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846725_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846733_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846741_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846749_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846766_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846774_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846782_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846790_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846798_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846806_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846814_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846822_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846830_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3846838_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847146_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847154_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847162_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847170_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847178_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847186_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847194_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847202_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847210_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847350_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3847358_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3850703_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3850712_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3851209_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3851218_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3851232_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3851694_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3851970_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3852081_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3852299_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3852308_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3852484_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3852501_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3853186_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3853646_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3853655_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3853663_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3853671_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3854436_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3874274_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3874306_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3874352_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3874353_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3875661_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3875670_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3875678_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3875686_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3875694_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3875702_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3876409_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3876956_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3876964_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3877298_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3877337_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3877348_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3877359_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3879727_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3879744_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3879752_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3879760_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3879768_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3879784_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3894288_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3894295_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3894297_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3894298_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3894594_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3894603_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3894611_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3894619_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3894627_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3895045_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3895054_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3895062_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3895070_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3895489_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3895501_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3895756_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897678_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897686_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897697_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897705_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897713_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897721_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897737_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897745_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897753_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897761_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897769_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3897777_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898574_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898582_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898590_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898598_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898606_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898620_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898631_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898639_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898783_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898791_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898799_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898810_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898818_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898826_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898837_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898851_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898859_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898867_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898875_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898883_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898902_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898910_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898918_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3898926_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3899743_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3899757_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3899765_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3899788_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3899796_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3899804_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3899886_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3899894_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3899902_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901075_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901084_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901092_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901132_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901143_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901158_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901166_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901174_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901600_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3901608_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3902008_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3902029_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3902402_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3902414_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3902976_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3903966_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3903998_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3904415_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3904865_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3904885_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3904904_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3904932_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3904944_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3905006_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3906962_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907319_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907327_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907335_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907801_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907835_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907852_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907866_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907880_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907891_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907905_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907919_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3907980_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3908146_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3908167_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3908202_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3908296_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3908333_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3908348_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3908461_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3908730_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3908996_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909011_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909027_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909123_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909131_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909156_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909207_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909216_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909371_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909400_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909734_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909754_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909876_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909884_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3909990_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3910016_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3910177_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3910203_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3910253_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3910283_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3910294_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3911208_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3911221_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3912036_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3912131_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3912556_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3912600_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3912619_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3912800_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3913133_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3913197_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3914637_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915132_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915164_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915215_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915217_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915218_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915219_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915220_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915221_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915601_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915615_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915635_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915655_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915669_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915677_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915942_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915950_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915958_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3915966_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3916018_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3916026_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3917728_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3918042_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3920130_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3920328_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3920347_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3920654_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3920900_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3920929_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3921055_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3921173_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3921389_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3921400_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3921581_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3921624_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3922207_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3922221_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3922360_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3922657_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3922687_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3922755_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3922827_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923189_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923314_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923322_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923500_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923522_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923548_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923592_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923611_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923649_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923663_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923945_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3923970_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3925860_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3925874_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3925984_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3925994_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3926116_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3926128_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3926435_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3926620_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3926756_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3926776_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3926791_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3926848_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3926907_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927138_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927197_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927211_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927288_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927367_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927389_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927465_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927578_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927699_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3927812_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3928323_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3928350_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3929176_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3929193_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3932910_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3932954_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3932965_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3933093_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3933207_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3933972_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3933985_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3934047_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3934436_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3934558_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3934606_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3934799_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3935148_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3935671_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3936110_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3936295_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3936346_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3936359_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3936491_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3936682_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3937601_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3937656_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3937974_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3937995_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3938008_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3938131_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3938166_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3938325_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3938343_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3938429_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3939424_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3939434_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3939576_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3939753_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3939813_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3939888_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3939928_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3939959_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3940223_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3940253_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3940270_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3940452_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3940619_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3940945_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3941055_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3941076_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3941122_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3941401_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3941548_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3941652_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3941814_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3941860_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3942003_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3942201_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3942427_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3946116_1 | SOURCEANDSINK | CABLE | DATA
Port_3946352_1 | SOURCEANDSINK | CABLE | DATA
Port_3947679_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3947735_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3947892_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3951235_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_3951254_1 | SOURCEANDSINK | CABLE | ELECTRICAL
