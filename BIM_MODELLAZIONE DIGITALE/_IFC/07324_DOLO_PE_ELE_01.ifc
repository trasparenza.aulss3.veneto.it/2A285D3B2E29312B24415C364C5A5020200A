Properties of the parts of a building model (IFC4), part 3 of 4

# IfcDistributionPort (2189)
Name | FlowDirection | PredefinedType | SystemType
Port_4130976_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4290032_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4130984_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131587_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4130984_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131614_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131019_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565517_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131019_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131570_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131094_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565519_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131094_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565521_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131131_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565517_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131131_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565523_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131148_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 21
Port_4131148_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 21
Port_4131151_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 21
Port_4131151_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 21
Port_4131291_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565519_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131291_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565525_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131308_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565523_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131308_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565525_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131322_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565521_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131322_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565527_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131332_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565529_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131332_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565533_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131341_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565527_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131341_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565529_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131363_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565531_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131363_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565533_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131379_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565531_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131379_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565535_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131434_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131434_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565535_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131570_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131588_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131587_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131588_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131612_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131658_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131612_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131614_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131650_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131658_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131650_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131713_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131711_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131711_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131713_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4131979_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132382_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132327_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4135640_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4132327_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4135642_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4132360_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4136073_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132360_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132379_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132371_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132379_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132371_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132392_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132382_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132392_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4132544_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132558_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132544_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132570_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132556_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4565507_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132556_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132558_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132564_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132570_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132564_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132594_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132592_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132829_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132592_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132594_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132663_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132663_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4134865_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132817_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132845_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132817_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132829_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132845_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132846_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132846_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4134865_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 13
Port_4132893_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132907_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132893_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132919_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132905_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4565505_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132905_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132907_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132913_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132919_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132913_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132962_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132960_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132995_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132960_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132962_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132981_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132995_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132981_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4133008_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4132998_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4133008_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4133093_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133298_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133093_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133325_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133311_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133325_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133311_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4133327_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4134740_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 18
Port_4134740_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 18
Port_4135125_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4135173_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4135125_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 14
Port_4135594_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4135610_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4135594_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4135642_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4136029_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4137521_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4136029_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4136073_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4137547_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4137956_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4138139_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4139268_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4139297_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4139455_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4139469_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4139589_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4139774_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4139785_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4139846_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4139914_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4140004_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4140092_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4140122_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4140148_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4140195_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4140483_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4142395_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4142410_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4145311_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4149367_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4149429_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4149488_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4149561_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4149759_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4150046_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4150136_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4150171_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4150895_1 | SOURCEANDSINK | CABLE | DATA
Port_4153130_1 | SOURCEANDSINK | CABLE | DATA
Port_4153237_1 | SOURCEANDSINK | CABLE | DATA
Port_4153332_1 | SOURCEANDSINK | CABLE | DATA
Port_4153343_1 | SOURCEANDSINK | CABLE | DATA
Port_4153411_1 | SOURCEANDSINK | CABLE | DATA
Port_4153478_1 | SOURCEANDSINK | CABLE | DATA
Port_4153669_1 | SOURCEANDSINK | CABLE | DATA
Port_4153688_1 | SOURCEANDSINK | CABLE | DATA
Port_4153747_1 | SOURCEANDSINK | CABLE | DATA
Port_4153764_1 | SOURCEANDSINK | CABLE | DATA
Port_4153843_1 | SOURCEANDSINK | CABLE | DATA
Port_4153856_1 | SOURCEANDSINK | CABLE | DATA
Port_4153940_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154013_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154019_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154021_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154023_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154024_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154040_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154041_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154049_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154051_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154060_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154071_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154073_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154075_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154114_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154126_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154140_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154150_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154158_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154160_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154175_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154177_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154179_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154183_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154185_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154187_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4154190_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4168533_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4168588_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4289893_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565537_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4289893_2 | SOURCEANDSINK | DUCT | VENTILATION
Port_4290020_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4565537_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4290020_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4290032_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 20
Port_4290785_1 | SOURCEANDSINK | CABLE | DATA
Port_4290965_1 | SOURCEANDSINK | CABLE | DATA
Port_4292075_1 | SOURCEANDSINK | CABLE | DATA
Port_4292275_1 | SOURCEANDSINK | CABLE | DATA
Port_4292593_1 | SOURCEANDSINK | CABLE | DATA
Port_4292699_1 | SOURCEANDSINK | CABLE | DATA
Port_4319861_1 | SOURCEANDSINK | CABLE | DATA
Port_4319886_1 | SOURCEANDSINK | CABLE | DATA
Port_4320202_1 | SOURCEANDSINK | CABLE | DATA
Port_4320212_1 | SOURCEANDSINK | CABLE | DATA
Port_4320476_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4320578_1 | SOURCEANDSINK | CABLE | DATA
Port_4320646_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4320661_1 | SOURCEANDSINK | CABLE | DATA
Port_4320682_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4320716_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4320767_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4320839_1 | SOURCEANDSINK | CABLE | DATA
Port_4321034_1 | SOURCEANDSINK | CABLE | DATA
Port_4321047_1 | SOURCEANDSINK | CABLE | DATA
Port_4321158_1 | SOURCEANDSINK | CABLE | DATA
Port_4321186_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4321326_1 | SOURCEANDSINK | CABLE | DATA
Port_4321438_1 | SOURCEANDSINK | CABLE | DATA
Port_4321468_1 | SOURCEANDSINK | CABLE | DATA
Port_4321907_1 | SOURCEANDSINK | CABLE | DATA
Port_4322014_1 | SOURCEANDSINK | CABLE | DATA
Port_4322862_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4323011_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4323090_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4323183_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4323762_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4323807_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4323831_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4326045_1 | SOURCEANDSINK | CABLE | DATA
Port_4326070_1 | SOURCEANDSINK | CABLE | DATA
Port_4326198_1 | SOURCEANDSINK | CABLE | DATA
Port_4326354_1 | SOURCEANDSINK | CABLE | DATA
Port_4326576_1 | SOURCEANDSINK | CABLE | DATA
Port_4326587_1 | SOURCEANDSINK | CABLE | DATA
Port_4326595_1 | SOURCEANDSINK | CABLE | DATA
Port_4326599_1 | SOURCEANDSINK | CABLE | DATA
Port_4326633_1 | SOURCEANDSINK | CABLE | DATA
Port_4327036_1 | SOURCEANDSINK | CABLE | DATA
Port_4327214_1 | SOURCEANDSINK | CABLE | DATA
Port_4327417_1 | SOURCEANDSINK | CABLE | DATA
Port_4327443_1 | SOURCEANDSINK | CABLE | DATA
Port_4327869_1 | SOURCEANDSINK | CABLE | DATA
Port_4331656_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4332131_1 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_4332550_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4332592_2 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
InPort_4332554_2 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4332550_2 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
InPort_4332592_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
OutPort_4332574_1 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 2
InPort_4332638_2 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 12
OutPort_4332628_0 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 12
InPort_4332628_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 3
OutPort_4332705_1 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 3
InPort_4332703_1 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 3
InPort_4332705_2 | SINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 3
OutPort_4332703_2 | SOURCE | DUCT | VENTILATION | Group: Meccanico Aria di mandata 3
Port_4332998_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4565539_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4332998_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333005_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333062_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333136_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333062_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4565539_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333126_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333136_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333126_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333156_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333154_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333154_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333156_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di mandata 1
Port_4333269_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333287_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333269_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333371_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333307_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333317_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333307_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333339_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333337_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333482_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333337_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333339_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333369_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333408_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333369_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333371_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333398_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333408_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333398_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333544_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333472_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333482_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333472_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333526_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333524_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333524_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333526_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 4
Port_4333542_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333542_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333544_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 5
Port_4333592_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334119_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4333592_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4333594_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334119_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4333594_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334228_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4333597_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334255_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4333597_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334230_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4333598_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334228_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4333598_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334230_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4333600_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4333600_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334144_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334144_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334239_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334239_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334255_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 26
Port_4334311_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334321_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334311_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334353_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334351_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334424_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334351_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334353_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334410_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334424_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334410_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334446_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334444_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334523_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334444_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334446_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334513_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334523_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334513_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334548_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334546_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334546_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334548_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 2
Port_4334801_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334811_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334801_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334837_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334835_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334928_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334835_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334837_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334862_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334872_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334862_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334897_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334895_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334948_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334895_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334897_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334916_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334928_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334916_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334972_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334938_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334948_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334938_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334999_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334970_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334970_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334972_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 7
Port_4334997_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334997_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4334999_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 6
Port_4335312_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335322_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335312_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335374_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335332_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335342_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335332_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335392_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335372_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335427_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335372_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335374_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335390_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335462_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335390_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335392_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335415_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335427_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335415_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335506_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335450_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335462_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335450_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335490_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335488_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335488_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335490_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 11
Port_4335504_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335504_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335506_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 22
Port_4335939_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4335949_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4335939_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336008_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4335967_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4335977_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4335967_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336024_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336006_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336057_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336006_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336008_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336022_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336079_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336022_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336024_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336045_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336057_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336045_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336105_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336067_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336079_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336067_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336125_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336103_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336103_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336105_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 9
Port_4336123_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336123_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4336125_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 8
Port_4342578_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342592_3 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342578_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342608_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342592_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342593_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342597_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342608_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342597_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342698_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342664_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358358_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342664_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358366_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342696_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358360_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342696_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342698_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342717_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342723_3 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342717_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342738_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342723_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342724_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342730_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342738_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342730_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342773_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342771_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342771_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342773_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 16
Port_4342915_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358366_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342915_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358368_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342948_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4342948_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358368_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4346644_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4358356_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358358_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358356_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358360_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 15
Port_4358501_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4362387_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4362461_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4362619_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4371945_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4362619_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4371947_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4362648_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4371976_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4362648_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4371947_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4362716_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4362775_1 | SOURCEANDSINK | CABLE | SECURITY
Port_4371966_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4371976_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4371966_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372015_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4371986_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372131_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4371986_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372135_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372005_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372015_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372005_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372131_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372085_0 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4565515_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372085_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4565541_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372133_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372135_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4372133_2 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4565541_1 | SOURCEANDSINK | DUCT | VENTILATION | Group: Meccanico Aria di ritorno 17
Port_4373510_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4373527_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4373557_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4373575_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4373589_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4373679_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4373828_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4373903_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4374056_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4374148_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4374159_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4378460_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4381343_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4381365_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4381571_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4381600_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4381839_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4381868_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4382267_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4384479_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4385027_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4389748_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4390752_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391547_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391293_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391316_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391293_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391320_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391310_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391312_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391311_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391312_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391311_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391316_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391547_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391569_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391561_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4391569_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393170_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393710_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393170_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395657_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393708_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393710_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393708_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393711_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393709_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393711_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393709_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393912_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4393912_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394099_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394032_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394107_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394032_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394108_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394074_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394107_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394074_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4396589_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394099_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394101_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394100_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394101_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394100_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4394108_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395452_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395674_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395452_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395832_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395655_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395657_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395655_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395659_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395656_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395659_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395656_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395674_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395831_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395832_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4395831_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4396587_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4396558_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4396587_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4396558_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4396589_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4396885_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4397261_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4396885_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4397255_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4397261_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4397255_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398233_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398249_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398233_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398253_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398244_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398245_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398244_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398249_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398775_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398777_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398775_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398778_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398776_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398778_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398776_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522652_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398784_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522652_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4398784_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522684_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4410437_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4422497_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4422631_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4511856_1 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_4521924_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522667_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4521924_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522688_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522047_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4523344_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522261_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4523344_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522261_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522277_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522543_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4569753_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522543_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522667_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522670_0 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522684_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522670_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4522688_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4523271_1 | SOURCEANDSINK | CABLECARRIER | CONVEYING
Port_4569753_2 | SOURCEANDSINK | CABLECARRIER | CONVEYING

# IfcDistributionSystem: Aria di mandata (3)
PredefinedType: VENTILATION
Name
Meccanico Aria di mandata 1
Meccanico Aria di mandata 2
Meccanico Aria di mandata 3

# IfcDistributionSystem: Aria di ritorno (25)
PredefinedType: VENTILATION
Name
Meccanico Aria di ritorno 1
Meccanico Aria di ritorno 12
Meccanico Aria di ritorno 2
Meccanico Aria di ritorno 3
Meccanico Aria di ritorno 4
Meccanico Aria di ritorno 5
Meccanico Aria di ritorno 6
Meccanico Aria di ritorno 7
Meccanico Aria di ritorno 8
Meccanico Aria di ritorno 9
Meccanico Aria di ritorno 11
Meccanico Aria di ritorno 10
Meccanico Aria di ritorno 22
Meccanico Aria di ritorno 14
Meccanico Aria di ritorno 13
Meccanico Aria di ritorno 23
Meccanico Aria di ritorno 24
Meccanico Aria di ritorno 15
Meccanico Aria di ritorno 16
Meccanico Aria di ritorno 19
Meccanico Aria di ritorno 17
Meccanico Aria di ritorno 20
Meccanico Aria di ritorno 21
Meccanico Aria di ritorno 18
Meccanico Aria di ritorno 26

# IfcDuctFitting: Raccordi condotto : M_Gomito circolare - Ad angolo : Standard (56)
In: 3 - Piano Terzo
Type - PredefinedType: CONNECTOR; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Raccordo
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.62.06
Pset Main Dimensions - Main Dimensions: Ø20mm
Abaco IFCGUID - Famiglia e tipo: M_Gomito circolare - Ad angolo: Standard; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Raccordi condotto : M_Gomito circolare - Ad angolo :...) | Group
2 x  Standard | Meccanico Aria di mandata 1
2 x  Standard | Meccanico Aria di ritorno 2
2 x  Standard | Meccanico Aria di ritorno 3
2 x  Standard | Meccanico Aria di ritorno 4
2 x  Standard | Meccanico Aria di ritorno 5
2 x  Standard | Meccanico Aria di ritorno 6
2 x  Standard | Meccanico Aria di ritorno 7
2 x  Standard | Meccanico Aria di ritorno 8
2 x  Standard | Meccanico Aria di ritorno 9
2 x  Standard | Meccanico Aria di ritorno 22
2 x  Standard | Meccanico Aria di ritorno 11
 Standard | Meccanico Aria di ritorno 23
 Standard | Meccanico Aria di ritorno 24
 Standard | Meccanico Aria di ritorno 1
3 x  Standard | Meccanico Aria di mandata 2
7 x  Standard | Meccanico Aria di ritorno 16
8 x  Standard | Meccanico Aria di ritorno 17
 Standard | Meccanico Aria di ritorno 21
3 x  Standard | Meccanico Aria di ritorno 20
2 x  Standard | Meccanico Aria di ritorno 13
3 x  Standard | Meccanico Aria di ritorno 14
4 x  Standard | Meccanico Aria di ritorno 15

# IfcDuctFitting: Raccordi condotto : M_Raccordo a T circolare : Standard (4)
In: 3 - Piano Terzo
Type - PredefinedType: CONNECTOR; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Raccordo
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.62.06
Pset Main Dimensions - Main Dimensions: Ø20mm
Abaco IFCGUID - Famiglia e tipo: M_Raccordo a T circolare: Standard; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Raccordi condotto : M_Raccordo a T circolare :...) | Group
 Standard | Meccanico Aria di ritorno 20
 Standard | Meccanico Aria di ritorno 13
 Standard | Meccanico Aria di ritorno 15
 Standard | Meccanico Aria di ritorno 16

# IfcDuctFitting: Raccordi condotto : M_Transizione circolare - Angolo : 30 gradi (155)
In: 3 - Piano Terzo
Type - PredefinedType: CONNECTOR; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Transizione
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_EPU - RIF_EPU: VEN24-10.01.62.06
Pset Main Dimensions - Main Dimensions: Ø20mm
Abaco IFCGUID - Famiglia e tipo: M_Transizione circolare - Angolo: 30 gradi; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Raccordi condotto : M_Transizione circolare - Angolo :...) | RIF_Crono | Group
4 x  30 gradi | M3_S6_G75 | Meccanico Aria di mandata 1
5 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 4
5 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 5
5 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 7
5 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 6
5 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 9
5 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 8
6 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 11
6 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 22
 30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 23
8 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 13
 30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 24
7 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 14
2 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 12
9 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 15
12 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 16
21 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 17
 30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 21
4 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 20
 30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 18
2 x  30 gradi | M3_S6_G75 | Meccanico Aria di mandata 2
 30 gradi | M3_S6_G75 | Meccanico Aria di mandata 3
5 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 26
5 x  30 gradi | M3_S6_G75 | Meccanico Aria di ritorno 2
2 x  30 gradi | M3_S6_G20 | Meccanico Aria di mandata 1
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 1
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 2
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 3
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 4
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 5
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 6
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 7
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 8
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 9
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 14
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 13
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 15
 30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 16
3 x  30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 17
11 x  30 gradi | M3_S6_G20 | Meccanico Aria di ritorno 20

# IfcElectricAppliance: Apparecchi elettrici : F_PRESA_INTERBLOCCATA : 1P+T (6)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Presa interbloccata CEE Monofase
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+T; Nominal Power: 500 W
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.46.16
Pset Main Dimensions - Main Dimensions: 103x220x150mm
Abaco IFCGUID - Famiglia e tipo: F_PRESA_INTERBLOCCATA: 1P+T; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricAppliance: Apparecchi elettrici : F_PRESA_INTERBLOCCATA : 3P+N+T (8)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Presa interbloccata CEE Trifase + Neutro
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 3P+N+T; Nominal Power: 1500 W
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.46.17/VEN24-10.01.46.18
Pset Main Dimensions - Main Dimensions: 103x220x150mm
Abaco IFCGUID - Famiglia e tipo: F_PRESA_INTERBLOCCATA: 3P+N+T; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricAppliance: Apparecchi elettrici : F_PUNTO DI ALIMENTAZIONE : Three phase+neutral power supply (9)
In: 4 - Piano Copertura
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: PC
Pset Descrizione_Entità - Descrizione: Punto di alimentazione trifase+neutro
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.1
