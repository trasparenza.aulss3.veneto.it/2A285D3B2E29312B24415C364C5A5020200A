Properties of the parts of a building model (IFC4), part 4 of 4

# IfcElectricAppliance: Apparecchi elettrici : F_PUNTO DI ALIMENTAZIONE : Three phase+neutral power supply (9)
Pset Electrical Properties - Voltage: 230V; Phases: 3P+N; Nominal Power: 20000 W
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: ELE.065/ELE.066
Pset Main Dimensions - Main Dimensions: Collegamento tramite cavo - consultare schemi quadri elettrici
Abaco IFCGUID - Famiglia e tipo: F_PUNTO DI ALIMENTAZIONE: Three phase+neutral power supply; WBS_01: DBE; WBS_02: IES; WBS_03: PC

# IfcElectricAppliance: Apparecchi elettrici : F_PUNTO DI ALIMENTAZIONE E COLLEGAMENTO : MONOFASE (65)
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Punto di alimentazione apparecchiatura
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.1
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 3000 W
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: ELE.006
Pset Main Dimensions - Main Dimensions: Collegamento tramite cavo - consultare schemi quadri elettrici
Abaco IFCGUID - Famiglia e tipo: F_PUNTO DI ALIMENTAZIONE E COLLEGAMENTO: MONOFASE; WBS_01: DBE; WBS_02: IES
Name (Apparecchi elettrici : F_PUNTO DI ALIMENTAZIONE E COLLEGAMENTO :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03
63 x  MONOFASE | 3 - Piano Terzo | P03
2 x  MONOFASE | 4 - Piano Copertura | PC

# IfcElectricAppliance: Dispositivi allarme incendio : F_LED RIPETITORE : RIPETITORE FUORI PORTA (26)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Led ripetitore fuori porta per locale
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.4
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 2 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.11.01
Pset Main Dimensions - Main Dimensions: 100x50x30mm
Abaco IFCGUID - Famiglia e tipo: F_LED RIPETITORE: RIPETITORE FUORI PORTA; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricAppliance: Dispositivi allarme incendio : F_SERRANDA TAGLIAFUOCO : F_SERRANDA TAGLIAFUOCO (51)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Punto di collegamento serranda tagliafuoco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.1
Pset Electrical Properties - Nominal Power: 15 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.059
Pset Main Dimensions - Main Dimensions: Cavo di alimentazione serranda tagliafuoco - Consultare schema quadro elettrico di pertinenza
Abaco IFCGUID - Famiglia e tipo: F_SERRANDA TAGLIAFUOCO: F_SERRANDA TAGLIAFUOCO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricAppliance: Dispositivi chiamata infermiera : F_LAMPADA DI SEGNALAZIONE : F_LAMPADA DI SEGNALAZIONE (7)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Lampada di segnalazione
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.4
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 2 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.024
Abaco IFCGUID - Famiglia e tipo: F_LAMPADA DI SEGNALAZIONE: F_LAMPADA DI SEGNALAZIONE; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricAppliance: Dispositivi chiamata infermiera : F_LAMPADA DI SEGNALAZIONE : LAMPADA DI SEGNALAZIONE- SENZA TONO E SENZA ELETTRONICA (18)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Lamada di segnalazione impianto di chiamata infermieri
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.4
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 2 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.025
Abaco IFCGUID - Famiglia e tipo: F_LAMPADA DI SEGNALAZIONE: LAMPADA DI SEGNALAZIONE- SENZA TONO E SENZA ELETTRONICA; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricAppliance: Dispositivi di sicurezza : F_CONTATTO MAGNETICO : CONTATTO MAGN._CONTROLLO ACCESSI
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Contatto magnetico impianto di controllo accessi
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.2
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 2 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.069
Pset Main Dimensions - Main Dimensions: 50x20x20mm
Abaco IFCGUID - Famiglia e tipo: F_CONTATTO MAGNETICO: CONTATTO MAGN._CONTROLLO ACCESSI; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricAppliance: Dispositivi di sicurezza : F_ELETTROSERRATURA : F_ELETTROSERRATURA (5)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Elettroserratura impianto di controllo accessi
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.2
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 2 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.01.46.22
Pset Main Dimensions - Main Dimensions: 150x100x20mm
Abaco IFCGUID - Famiglia e tipo: F_ELETTROSERRATURA: F_ELETTROSERRATURA; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricAppliance: Dispositivi di sicurezza : F_MONITORAGGIO AMBIENTALE : SONDA DI PRESSIONE (6)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Alimentazione sonda di pressione
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 1 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.003
Pset Main Dimensions - Main Dimensions: 80x80x20mm
Abaco IFCGUID - Famiglia e tipo: F_MONITORAGGIO AMBIENTALE: SONDA DI PRESSIONE; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Apparecchi elettrici : F_PRESA_SU SCATOLA DA ESTERNO_IP55 : N.1 UNIVERSALE SU SCATOLA A 3 MODULI (3)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Presa elettrica di tipo UNEL su scatola da esterno IP55
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Nominal Power: 300 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.46.11
Pset Main Dimensions - Main Dimensions: 95x70x48mm
Abaco IFCGUID - Famiglia e tipo: F_PRESA_SU SCATOLA DA ESTERNO_IP55: N.1 UNIVERSALE SU SCATOLA A 3 MODULI; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Apparecchi elettrici : F_PRESA_SU SCATOLA DA INCASSO : N.1 UNIVERSALE SU SCATOLA 503 (71)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Presa elettrica di tipo UNEL su scatola da incasso
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Nominal Power: 300 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.44.11
Pset Main Dimensions - Main Dimensions: 95x70x48mm
Abaco IFCGUID - Famiglia e tipo: F_PRESA_SU SCATOLA DA INCASSO: N.1 UNIVERSALE SU SCATOLA 503; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Apparecchi elettrici : F_PULSANTI SALI-SCENDI_SU SCATOLA DA INCASSO : N.1 PULSANTE SU SCATOLA 503 (15)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Pulsanti sali-scendi su scatola da incasso per attenuazione tapparelle
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Nominal Power: 0 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.45.17
Pset Main Dimensions - Main Dimensions: 95x70x48mm
Abaco IFCGUID - Famiglia e tipo: F_PULSANTI SALI-SCENDI_SU SCATOLA DA INCASSO: N.1 PULSANTE SU SCATOLA 503; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Apparecchi elettrici : F_QUADRO ELETTRICO : F_QUADRO ELETTRICO (31)
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Default
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Quadro elettrico (per maggiori dettagli consultare elaborati grafici 07324-E-ELE-EG-SC-NA-005 e planimetrie)
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset Electrical Properties - Phases: 3P+N+T
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: ELE.017/ELE.018/ELE.019/ELE.020/ELE.021/ELE.010/ELE.011/ELE.012/ELE.022/ELE.007/ELE.008/ELE.009
Abaco IFCGUID - Famiglia e tipo: F_QUADRO ELETTRICO: F_QUADRO ELETTRICO; WBS_01: DBE; WBS_02: IES
Name (Apparecchi elettrici : F_QUADRO ELETTRICO :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03 | Voltage | Nominal Power (W) | Main Dimensions
6 x  F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 3500 | 2082x600x220mm
 F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 91300 | 2130x1995x257mm
6 x  F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 8000 | 800x1400x450mm
2 x  F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 15000 | 1400x600x840mm
2 x  F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 15000 | 800x450x800mm
 F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 164700 | 1256x2000x465mm
 F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 7340 | 2130x900x257mm
 F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 22300 | 2130x1150x257mm
6 x  F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 5000 | 2082x600x220mm
2 x  F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 24V | 15 | 250x400x200mm
 F_QUADRO ELETTRICO | 4 - Piano Copertura | PC | 230V | 147500 | 1700x2000x500mm
 F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 8500 | 1400x800x450mm
 F_QUADRO ELETTRICO | 3 - Piano Terzo | P03 | 230V | 8500 | 1400x840x600mm

# IfcElectricDistributionBoard: Apparecchi elettrici : F_Termostato : F_Termostato (36)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Punto di alimentazione termostato
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 10 W
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: ELE.003
Pset Main Dimensions - Main Dimensions: 80x90x20mm
Abaco IFCGUID - Famiglia e tipo: F_Termostato: F_Termostato; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Apparecchi elettrici : PostazioneLavoroUffici2 : FMT31_PostazioneFMTD504_PL2 (3)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Postazione Lavoro Tipo 2
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 1500 W
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.44.11
Pset Main Dimensions - Main Dimensions: 250x200x48mm
Abaco IFCGUID - Famiglia e tipo: PostazioneLavoroUffici2: FMT31_PostazioneFMTD504_PL2; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi chiamata infermiera : F_MODULO DI CHIAMATA-PRESENZA : MODULO DI CHIAMATA A TIRANTE (4)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Modulo di chiamata disabili
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 1 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.028
Abaco IFCGUID - Famiglia e tipo: F_MODULO DI CHIAMATA-PRESENZA: MODULO DI CHIAMATA A TIRANTE; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi chiamata infermiera : F_MODULO DI CHIAMATA-PRESENZA : MODULO DI CHIAMATA/ANNULLO (12)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Modulo di chiamata infermieri
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 1 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.029
Abaco IFCGUID - Famiglia e tipo: F_MODULO DI CHIAMATA-PRESENZA: MODULO DI CHIAMATA/ANNULLO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi chiamata infermiera : F_MODULO DI CHIAMATA-PRESENZA : MODULO DI PRESENZA/ANNULLO (4)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Modulo di chiamata disabili
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 1 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.026
Abaco IFCGUID - Famiglia e tipo: F_MODULO DI CHIAMATA-PRESENZA: MODULO DI PRESENZA/ANNULLO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi chiamata infermiera : F_PULSANTIERA PAZIENTE : PULSANTIERA PAZIENTE CON CHIAMATA (12)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Pulsantiera paziente impianto di chiamata infermieri
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.8.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 0 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.026
Abaco IFCGUID - Famiglia e tipo: F_PULSANTIERA PAZIENTE: PULSANTIERA PAZIENTE CON CHIAMATA; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi di illuminazione : F_PULSANTE_SU SCATOLA DA ESTERNO_IP55 : N.1 PULSANTE SU SCATOLA A 3 MODULI (9)
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Pulsante accensione su scatola da esterno IP55
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.46.09
Abaco IFCGUID - Famiglia e tipo: F_PULSANTE_SU SCATOLA DA ESTERNO_IP55: N.1 PULSANTE SU SCATOLA A 3 MODULI; WBS_01: DBE; WBS_02: IES
Name (Dispositivi di illuminazione : F_PULSANTE_SU SCATOLA DA ESTERNO_IP55 :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03
6 x  N.1 PULSANTE SU SCATOLA A 3 MODULI | 3 - Piano Terzo | P03
3 x  N.1 PULSANTE SU SCATOLA A 3 MODULI | 4 - Piano Copertura | PC

# IfcElectricDistributionBoard: Dispositivi di illuminazione : F_PULSANTI_SU SCATOLA DA INCASSO : N.1 PULSANTE SU SCATOLA 503 (21)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Pulsante accensione su scatola da incasso
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.44.15
Abaco IFCGUID - Famiglia e tipo: F_PULSANTI_SU SCATOLA DA INCASSO: N.1 PULSANTE SU SCATOLA 503; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi di illuminazione : F_RAGNETTO KNX : RAGNETTO_4DI (25)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Modulo KNX "ragnetto" per pulsante di accensione luci
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: 225010b
Abaco IFCGUID - Famiglia e tipo: F_RAGNETTO KNX: RAGNETTO_4DI; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi di illuminazione : F_Sensore di presenza : Sensore a presenza a parete incasso (21)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Sensore di presenza per accensione luci KNX
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.01.44.21
Abaco IFCGUID - Famiglia e tipo: F_Sensore di presenza: Sensore a presenza a parete incasso; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi di illuminazione : F_Sensore di presenza a soffitto - ON OFF : Sensore CONTROSOFFITTO ON/OFF (15)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Rilevatore di presenza ON/OFF
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.01.44.21
Abaco IFCGUID - Famiglia e tipo: F_Sensore di presenza a soffitto - ON OFF: Sensore CONTROSOFFITTO ON/OFF; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi di illuminazione : F_Sensore di presenza a soffitto : Sensore KNX (2)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Rilevatore KNX di presenza e luminosità
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: 225016a
Abaco IFCGUID - Famiglia e tipo: F_Sensore di presenza a soffitto: Sensore KNX; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi di illuminazione : F_Sensore di presenza a soffitto : Sensore Normale KNX (21)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Rilevatore KNX di presenza
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: 225016a
Abaco IFCGUID - Famiglia e tipo: F_Sensore di presenza a soffitto: Sensore Normale KNX; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi di illuminazione : Touch panel : CI_Lampada a parete_LED_DISANO_BOX_1209
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Touch panel per comando luci sala operatoria
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.061
Abaco IFCGUID - Famiglia e tipo: Touch panel: CI_Lampada a parete_LED_DISANO_BOX_1209; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricDistributionBoard: Dispositivi di sicurezza : F_PULSANTE SBOCCO PORTA_SU SCATOLA DA INCASSO : N.1 PULSANTE SU SCATOLA 503 (5)
In: 3 - Piano Terzo
Type - PredefinedType: SWITCHBOARD; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Pulsante sblocco porta per impianto di controllo accessi
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.4.3
Pset Electrical Properties - Nominal Power: 0 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.01.46.21/VEN24-10.01.44.09
Pset Main Dimensions - Main Dimensions: 95x70x48mm
Abaco IFCGUID - Famiglia e tipo: F_PULSANTE SBOCCO PORTA_SU SCATOLA DA INCASSO: N.1 PULSANTE SU SCATOLA 503; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcElectricTimeControl: Apparecchi elettrici : F_OROLOGIO CONTASECONDI-TASTIERA : OROLOGIO CONTASECONDI (6)
In: 3 - Piano Terzo
Type - PredefinedType: TIMECLOCK; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Orologio contasecondi asetticco
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Nominal Power: 50 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: ELE.006
Pset Main Dimensions - Main Dimensions: 400x200x100mm
Abaco IFCGUID - Famiglia e tipo: F_OROLOGIO CONTASECONDI-TASTIERA: OROLOGIO CONTASECONDI; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcLamp: Apparecchi per illuminazione : CI_Incasso_60x60_Controsoffitto : LAMPADA TENUTA 1200X600 170 W (38)
In: 3 - Piano Terzo
Type - PredefinedType: LED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Lampada da 170W per installazione a controsoffitto a tenuta RGB-W
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 170 W
Pset Lighting Fixtures Proprieties - Luminous flux: 10876 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.047
Pset Main Dimensions - Main Dimensions: 1200x600x100mm
Abaco IFCGUID - Famiglia e tipo: CI_Incasso_60x60_Controsoffitto: LAMPADA TENUTA 1200X600 170 W; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcLamp: Apparecchi per illuminazione : CI_Incasso_60x60_Controsoffitto : LAMPADA TENUTA 35W (106)
In: 3 - Piano Terzo
Type - PredefinedType: LED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Lampada da 35W per controsoffitto a tenuta
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 35 W
Pset Lighting Fixtures Proprieties - Luminous flux: 3978 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.041
Pset Main Dimensions - Main Dimensions: 600x600x95mm
Abaco IFCGUID - Famiglia e tipo: CI_Incasso_60x60_Controsoffitto: LAMPADA TENUTA 35W; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcLamp: Apparecchi per illuminazione : CI_Incasso_60x60_Controsoffitto : Ra+90 33W (46)
In: 3 - Piano Terzo
Type - PredefinedType: LED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Lampada da 33W per installazione a controsoffitto
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 33 W
Pset Lighting Fixtures Proprieties - Luminous flux: 3086 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.043/ELE.044
Pset Main Dimensions - Main Dimensions: 600x600x95mm
Abaco IFCGUID - Famiglia e tipo: CI_Incasso_60x60_Controsoffitto: Ra+90 33W; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Apparecchi per illuminazione : CI_Incasso_60x60_Controsoffitto :...)
45 x  Ra+90 33W
 Ra+90 33W | AB_ProperySet - IFC_Descriptions: PROVA 123

# IfcLamp: Apparecchi per illuminazione : CI_Incasso_60x60_Controsoffitto : Ra+90 47W (20)
In: 3 - Piano Terzo
Type - PredefinedType: LED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Lampada da 47W per installazione a controsoffitto
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 47 W
Pset Lighting Fixtures Proprieties - Luminous flux: 4250 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.045
Pset Main Dimensions - Main Dimensions: 600x600x95mm
Abaco IFCGUID - Famiglia e tipo: CI_Incasso_60x60_Controsoffitto: Ra+90 47W; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcLamp: Apparecchi per illuminazione : CI_Incasso_Faretti_Controsoffitto : FARETTO INCASSO 28W (15)
In: 3 - Piano Terzo
Type - PredefinedType: LED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Faretto da 28W per installazione a controsoffitto
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 28 W
Pset Lighting Fixtures Proprieties - Luminous flux: 2757 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.046
Pset Main Dimensions - Main Dimensions: Ø166mm h:107mm
Abaco IFCGUID - Famiglia e tipo: CI_Incasso_Faretti_Controsoffitto: FARETTO INCASSO 28W; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcLamp: Apparecchi per illuminazione : CI_STAGNA_LED_IP65 : Lampada stagna IP65 34W (33)
Type - PredefinedType: LED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Armatura stagna IP65 34W
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 34 W
Pset Lighting Fixtures Proprieties - Luminous flux: 5194 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.048
Pset Main Dimensions - Main Dimensions: 1260x120x102mm
Abaco IFCGUID - Famiglia e tipo: CI_STAGNA_LED_IP65: Lampada stagna IP65 34W; WBS_01: DBE; WBS_02: IES
Name (Apparecchi per illuminazione : CI_STAGNA_LED_IP65 :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03
7 x  Lampada stagna IP65 34W | 3 - Piano Terzo | P03
26 x  Lampada stagna IP65 34W | 4 - Piano Copertura | PC

# IfcLightFixture: Apparecchi per illuminazione : CI_EMERGENZA_Parete_Bandiera : CI_Emergenza_Bandiera_Soffitto_PITTOGRAMMA (4)
In: 3 - Piano Terzo
Type - PredefinedType: SECURITYLIGHTING; Material: Eaton – (Pictogram, White), Eaton – (Pictogram, Green), Eaton – (Diffuser, Polycarbonate, Clear), Eaton – (Body, Polycarbonate, RAL7035)
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: IP65 LED Surface mounted 2W LED emergency double sided escape luminaire
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 2.5 W
Pset Lighting Fixtures Proprieties - Luminous flux: 50 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.053
Pset Main Dimensions - Main Dimensions: 231x125x34mm
Abaco IFCGUID - Famiglia e tipo: CI_EMERGENZA_Parete_Bandiera: CI_Emergenza_Bandiera_Soffitto_PITTOGRAMMA; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcLightFixture: Apparecchi per illuminazione : CI_EMERGENZA_Parete_Bandiera : CI_Emergenza_parete (33)
Type - PredefinedType: SECURITYLIGHTING; Material: Eaton – (Diffuser, Polycarbonate, Clear), Eaton – (Body, Polycarbonate, RAL7035)
Pset WBS - WBS_01: DBE; WBS_02: IES
Pset Descrizione_Entità - Descrizione: Lampada di emergenza a parete con pittogramma di emergenza
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Nominal Power: 15 W; Voltage: 230V; Phases: 1P+N
Pset Lighting Fixtures Proprieties - Luminous flux: 300 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.052
Pset Main Dimensions - Main Dimensions: 231x125x34mm
Abaco IFCGUID - Famiglia e tipo: CI_EMERGENZA_Parete_Bandiera: CI_Emergenza_parete; WBS_01: DBE; WBS_02: IES
Name (Apparecchi per illuminazione : CI_EMERGENZA_Parete_Bandiera :...) | In | Pset WBS, WBS_03 = Abaco IFCGUID, WBS_03
23 x  CI_Emergenza_parete | 3 - Piano Terzo | P03
10 x  CI_Emergenza_parete | 4 - Piano Copertura | PC

# IfcLightFixture: Apparecchi per illuminazione : CI_EMERGENZA_Parete_Bandiera : CI_Emergenza_parete_PITTOGRAMMA (27)
In: 3 - Piano Terzo
Type - PredefinedType: SECURITYLIGHTING; Material: Eaton – (Pictogram, White), Eaton – (Pictogram, Green), Eaton – (Diffuser, Polycarbonate, Clear), Eaton – (Body, Polycarbonate, RAL7035)
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: IP65 LED Surface mounted 2W LED emergency open area luminaire. with Legend
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 3 W
Pset Lighting Fixtures Proprieties - Luminous flux: 50 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.053
Pset Main Dimensions - Main Dimensions: 231x125x34mm
Abaco IFCGUID - Famiglia e tipo: CI_EMERGENZA_Parete_Bandiera: CI_Emergenza_parete_PITTOGRAMMA; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcLightFixture: Apparecchi per illuminazione : CI_EMERGENZA_soffitto_AS-SIMM : CI_Emergenza_soffitto_LED_Ottica_Asimmetrica (16)
In: 3 - Piano Terzo
Type - PredefinedType: SECURITYLIGHTING; Material: Eaton – (Body, polycarbonate and ABS blend, white), <Unnamed>, Eaton – (Lamp, Glass, Self Illuminating)
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Corpo illuminante ad incasso ottica asimmetrica
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 6 W
Pset Lighting Fixtures Proprieties - Luminous flux: 150 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.051
Pset Main Dimensions - Main Dimensions: 100x100x38mm
Abaco IFCGUID - Famiglia e tipo: CI_EMERGENZA_soffitto_AS-SIMM: CI_Emergenza_soffitto_LED_Ottica_Asimmetrica; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcLightFixture: Apparecchi per illuminazione : CI_EMERGENZA_soffitto_AS-SIMM : CI_Emergenza_soffitto_LED_Ottica_Simmetrica (20)
In: 3 - Piano Terzo
Type - PredefinedType: SECURITYLIGHTING; Material: Eaton – (Body, polycarbonate and ABS blend, white), <Unnamed>, Eaton – (Lamp, Glass, Self Illuminating)
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Corpo illuminante ad incasso ottica simmetrica
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.3
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 6 W
Pset Lighting Fixtures Proprieties - Luminous flux: 150 lm; Color Temperature: 4000 K
Pset RIF_Crono - RIF_Crono: M9_S32_G20
Pset RIF_EPU - RIF_EPU: ELE.050
Pset Main Dimensions - Main Dimensions: 100x100x38mm
Abaco IFCGUID - Famiglia e tipo: CI_EMERGENZA_soffitto_AS-SIMM: CI_Emergenza_soffitto_LED_Ottica_Simmetrica; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcPipeFitting: Accessori per condotti : F_FORO-CAPILLARE DI ASPIRAZIONE : FORO (74)
In: 3 - Piano Terzo
Type - PredefinedType: ENTRY; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Foro capilarre per impianto di aspirazione
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.2
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.21.07
Pset Main Dimensions - Main Dimensions: Ø20mm
Abaco IFCGUID - Famiglia e tipo: F_FORO-CAPILLARE DI ASPIRAZIONE: FORO; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Accessori per condotti : F_FORO-CAPILLARE DI ASPIRAZIONE :...) | Group
3 x  FORO | Meccanico Aria di mandata 1
 FORO | Meccanico Aria di ritorno 12
3 x  FORO | Meccanico Aria di ritorno 5
3 x  FORO | Meccanico Aria di ritorno 4
3 x  FORO | Meccanico Aria di ritorno 7
3 x  FORO | Meccanico Aria di ritorno 6
3 x  FORO | Meccanico Aria di ritorno 8
3 x  FORO | Meccanico Aria di ritorno 9
3 x  FORO | Meccanico Aria di ritorno 11
3 x  FORO | Meccanico Aria di ritorno 22
5 x  FORO | Meccanico Aria di ritorno 13
4 x  FORO | Meccanico Aria di ritorno 14
5 x  FORO | Meccanico Aria di ritorno 15
7 x  FORO | Meccanico Aria di ritorno 16
11 x  FORO | Meccanico Aria di ritorno 17
6 x  FORO | Meccanico Aria di ritorno 20
 FORO | Meccanico Aria di mandata 2
 FORO | Meccanico Aria di mandata 3
3 x  FORO | Meccanico Aria di ritorno 26
3 x  FORO | Meccanico Aria di ritorno 2

# IfcPipeFitting: Raccordi tubo protettivo : M_Gomito tubo protettivo - Acciaio : Standard (24)
In: 3 - Piano Terzo
Type - PredefinedType: BEND; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Gomito
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: VEN24-10.01.62.06
Pset Main Dimensions - Main Dimensions: Ø50mm
Abaco IFCGUID - Famiglia e tipo: M_Gomito tubo protettivo - Acciaio: Standard; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcPipeSegment: Condotto : Condotto circolare : Default (131)
In: 3 - Piano Terzo
Type - PredefinedType: RIGIDSEGMENT
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Tubazione per sistema di aspirazione rilevazione incendi
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.3
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.21.07
Pset Main Dimensions - Main Dimensions: Ø20mm
Abaco IFCGUID - Famiglia e tipo: Condotto circolare: Default; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Condotto : Condotto circolare :...) | Group
5 x  Default | Meccanico Aria di mandata 1
 Default | Meccanico Aria di ritorno 1
5 x  Default | Meccanico Aria di ritorno 2
2 x  Default | Meccanico Aria di ritorno 3
5 x  Default | Meccanico Aria di ritorno 4
5 x  Default | Meccanico Aria di ritorno 5
5 x  Default | Meccanico Aria di ritorno 6
5 x  Default | Meccanico Aria di ritorno 7
5 x  Default | Meccanico Aria di ritorno 8
5 x  Default | Meccanico Aria di ritorno 9
5 x  Default | Meccanico Aria di ritorno 22
5 x  Default | Meccanico Aria di ritorno 11
8 x  Default | Meccanico Aria di ritorno 13
7 x  Default | Meccanico Aria di ritorno 14
 Default | Meccanico Aria di ritorno 1; Meccanico Aria di mandata 2
3 x  Default | Meccanico Aria di mandata 2
10 x  Default | Meccanico Aria di ritorno 15
15 x  Default | Meccanico Aria di ritorno 16
19 x  Default | Meccanico Aria di ritorno 17
10 x  Default | Meccanico Aria di ritorno 20
 Default | Meccanico Aria di ritorno 12; Meccanico Aria di mandata 2
 Default | Meccanico Aria di ritorno 12; Meccanico Aria di mandata 3
3 x  Default | Meccanico Aria di ritorno 26

# IfcPipeSegment: Tubi protettivi : Tubo protettivo con raccordi : Tubo protettivo PVC (29)
In: 3 - Piano Terzo
Type - PredefinedType: RIGIDSEGMENT
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Tubazione PVC
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.01.62.06
Pset Main Dimensions - Main Dimensions: Ø50mm
Abaco IFCGUID - Famiglia e tipo: Tubo protettivo con raccordi: Tubo protettivo PVC; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcProtectiveDevice: Apparecchi elettrici : F_PULSANTE DI SGANCIO : PULSANTE DI SGANCIO (16)
In: 3 - Piano Terzo
Type - PredefinedType: CIRCUITBREAKER; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Pulsante di sgancio di emergenza
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 5.7.4
Pset Electrical Properties - Nominal Power: 0 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G75
Pset RIF_EPU - RIF_EPU: ELE.005
Pset Main Dimensions - Main Dimensions: 95x70x48mm
Abaco IFCGUID - Famiglia e tipo: F_PULSANTE DI SGANCIO: PULSANTE DI SGANCIO; WBS_01: DBE; WBS_02: IES; WBS_03: P03
Name (Apparecchi elettrici : F_PULSANTE DI SGANCIO :...)
15 x  PULSANTE DI SGANCIO
 PULSANTE DI SGANCIO | AB_ProperySet - IFC_Descriptions: Sgancio UTA

# IfcProtectiveDevice: Dispositivi allarme incendio : F_ELETTROMAGNETE RITENUTA PORTA : F_ELETTROMAGNETE RITENUTA PORTA (12)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Elettromagnete per ritenuta porta impianto rilevazione incendi
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.2
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 2 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.10.01
Pset Main Dimensions - Main Dimensions: Ø50mm
Abaco IFCGUID - Famiglia e tipo: F_ELETTROMAGNETE RITENUTA PORTA: F_ELETTROMAGNETE RITENUTA PORTA; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcProtectiveDevice: Dispositivi allarme incendio : F_PANNELLO OTTICO-ACUSTICO : F_PANNELLO OTTICO-ACUSTICO (26)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Pannello ottico acustico per impianto rilevazione fumi
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.4
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 15 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.02.01
Pset Main Dimensions - Main Dimensions: 300x150x50mm
Abaco IFCGUID - Famiglia e tipo: F_PANNELLO OTTICO-ACUSTICO: F_PANNELLO OTTICO-ACUSTICO; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcProtectiveDevice: Dispositivi allarme incendio : F_PULSANTE MANUALE : F_PULSANTE MANUALE (13)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Pulsante manuale per allarme impianto rilevazione incendi
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.3
Pset Electrical Properties - Nominal Power: 5 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.08.01
Pset Main Dimensions - Main Dimensions: 100x100x50mm
Abaco IFCGUID - Famiglia e tipo: F_PULSANTE MANUALE: F_PULSANTE MANUALE; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcProtectiveDevice: Dispositivi allarme incendio : F_RIVELATORE DI FUMO : CAMERA DI ANALISI (18)
In: 4 - Piano Copertura
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: PC
Pset Descrizione_Entità - Descrizione: Rivelatore per condotta aeraulica
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.2
Pset Electrical Properties - Nominal Power: 5 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.17.01
Pset Main Dimensions - Main Dimensions: 200x100x50mm
Abaco IFCGUID - Famiglia e tipo: F_RIVELATORE DI FUMO: CAMERA DI ANALISI; WBS_01: DBE; WBS_02: IES; WBS_03: PC

# IfcProtectiveDevice: Dispositivi allarme incendio : F_RIVELATORE DI FUMO : OTTICO IN AMBIENTE (70)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Rilevatore fumo ottico in ambiente
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.2
Pset Electrical Properties - Voltage: 230V; Phases: 1P+N; Nominal Power: 5 W
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.12.01
Pset Main Dimensions - Main Dimensions: Ø90mm h:50mm
Abaco IFCGUID - Famiglia e tipo: F_RIVELATORE DI FUMO: OTTICO IN AMBIENTE; WBS_01: DBE; WBS_02: IES; WBS_03: P03

# IfcProtectiveDevice: Dispositivi allarme incendio : F_RIVELATORE DI FUMO : OTTICO SOPRA CONTROSOFFITTO (29)
In: 3 - Piano Terzo
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset WBS - WBS_01: DBE; WBS_02: IES; WBS_03: P03
Pset Descrizione_Entità - Descrizione: Rilevatore ottico sopra controsoffitto + ripetitore
Pset ClassificationCode_UNI-8290 - ClassificationCode_UNI-8290: 6.1.2
Pset Electrical Properties - Nominal Power: 5 W; Voltage: 230V; Phases: 1P+N
Pset RIF_Crono - RIF_Crono: M3_S6_G20
Pset RIF_EPU - RIF_EPU: VEN24-10.16.12.02 + VEN24-10.16.11.02
Pset Main Dimensions - Main Dimensions: Ø90mm h:50mm
Abaco IFCGUID - Famiglia e tipo: F_RIVELATORE DI FUMO: OTTICO SOPRA CONTROSOFFITTO; WBS_01: DBE; WBS_02: IES; WBS_03: P03
